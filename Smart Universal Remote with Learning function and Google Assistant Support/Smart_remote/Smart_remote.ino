/*****************************************************************************************************
 * Poject      : Smart Universal Remote
 * Description : Smart Universal Remote with Learning function and Google Assistant Support
 * Author      : Jobit Joseph
 * For         : CircuitDigest
 * Date        : 10-06-2022
 * Copy Writes : © Jobit Joseph – Circuit Digest (Semicon Media Pvt Ltd)
 *****************************************************************************************************/
/*
   Connection pinout
   Pwr   -- Touch4 -- IO13
   Ok    -- touch  -- 6 io14
   up    -- touch9 -- io32
   down  -- touch8 -- i033
   left  -- touch5 -- io12
   right -- touch7 --  io27
   next  -- touch2 -- io2
   prev  -- touch3 -- io15
   plus  -- touch1 -- io0
   minus -- touch0 -- io4
   Mode  -- switch -- IO23
   Learn -- Switch -- IO22
*/
#include <Arduino.h>
#include <WiFi.h>
#include <ESPmDNS.h>
#include "SPIFFS.h"
#include "PinDefinitionsAndMore.h" //Define macros for input and output pin etc.
#include "src/WiFiManager.h"
#include "src/AsyncElegantOTA.h"
#include "src/IRremote.hpp"
#include "src/AsyncTCP.h"
#include "src/ESPAsyncWebServer.h"
#define mode_switch 23
#define learn_switch 22
#include "src/Adafruit_MQTT.h"
#include "src/Adafruit_MQTT_Client.h"

/************************* Adafruit.io Setup *********************************/

#define AIO_SERVER      "io.adafruit.com"
#define AIO_SERVERPORT  1883                   // use 8883 for SSL
#define AIO_USERNAME    "jobitxxxxxxxx"            // Replace it with your Adafruit IO username
#define AIO_KEY         "aio_qOXrxxxxxxxxxxxxxxxxxxM4yyyi4"   // Replace with your Adafruit IO Project Auth Key

WiFiClient client;
// Setup the MQTT client class by passing in the WiFi client and MQTT server and login details.
Adafruit_MQTT_Client mqtt(&client, AIO_SERVER, AIO_SERVERPORT, AIO_USERNAME, AIO_KEY);

/****************************** Feeds ***************************************/


// Setup a feed called 'onoff' for subscribing to changes.
Adafruit_MQTT_Subscribe SRemote = Adafruit_MQTT_Subscribe(&mqtt, AIO_USERNAME"/feeds/smart-remote"); // FeedName




// Create AsyncWebServer object on port 80
AsyncWebServer server(80);
AsyncWebSocket ws("/ws");

int STATUS_PIN = 19;

int DELAY_BETWEEN_REPEAT = 50;
int DEFAULT_NUMBER_OF_REPEATS_TO_SEND = 3;

/* Html page for the websever*/
const char index_html[] PROGMEM = R"rawliteral(
<!DOCTYPE html>
<html>
<head>
  <link rel="icon" type="image/png" href="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAlYAAAJmCAYAAACe386yAAAACXBIWXMAAAsTAAALEwEAmpwYAAAFu2lUWHRYTUw6Y29tLmFkb2JlLnhtcAAAAAAAPD94cGFja2V0IGJlZ2luPSLvu78iIGlkPSJXNU0wTXBDZWhpSHpyZVN6TlRjemtjOWQiPz4gPHg6eG1wbWV0YSB4bWxuczp4PSJhZG9iZTpuczptZXRhLyIgeDp4bXB0az0iQWRvYmUgWE1QIENvcmUgNy4xLWMwMDAgNzkuZWRhMmIzZiwgMjAyMS8xMS8xNC0xMjozMDo0MiAgICAgICAgIj4gPHJkZjpSREYgeG1sbnM6cmRmPSJodHRwOi8vd3d3LnczLm9yZy8xOTk5LzAyLzIyLXJkZi1zeW50YXgtbnMjIj4gPHJkZjpEZXNjcmlwdGlvbiByZGY6YWJvdXQ9IiIgeG1sbnM6eG1wPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvIiB4bWxuczpkYz0iaHR0cDovL3B1cmwub3JnL2RjL2VsZW1lbnRzLzEuMS8iIHhtbG5zOnBob3Rvc2hvcD0iaHR0cDovL25zLmFkb2JlLmNvbS9waG90b3Nob3AvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0RXZ0PSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VFdmVudCMiIHhtcDpDcmVhdG9yVG9vbD0iQWRvYmUgUGhvdG9zaG9wIDIzLjEgKFdpbmRvd3MpIiB4bXA6Q3JlYXRlRGF0ZT0iMjAyMi0wMy0yNFQxNTowMDozMSswNTozMCIgeG1wOk1vZGlmeURhdGU9IjIwMjItMDMtMjRUMTU6MjQ6MzQrMDU6MzAiIHhtcDpNZXRhZGF0YURhdGU9IjIwMjItMDMtMjRUMTU6MjQ6MzQrMDU6MzAiIGRjOmZvcm1hdD0iaW1hZ2UvcG5nIiBwaG90b3Nob3A6Q29sb3JNb2RlPSIzIiB4bXBNTTpJbnN0YW5jZUlEPSJ4bXAuaWlkOmVlYWNmYmJlLTFiODgtMTg0Mi1iY2NhLTRhMzk5NTIwYWU4MSIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDo0OTA5OTE1OC1iZDFhLTI0NDgtODg1NC1iODM2ODVhYzQ3MjciIHhtcE1NOk9yaWdpbmFsRG9jdW1lbnRJRD0ieG1wLmRpZDo0OTA5OTE1OC1iZDFhLTI0NDgtODg1NC1iODM2ODVhYzQ3MjciPiA8eG1wTU06SGlzdG9yeT4gPHJkZjpTZXE+IDxyZGY6bGkgc3RFdnQ6YWN0aW9uPSJjcmVhdGVkIiBzdEV2dDppbnN0YW5jZUlEPSJ4bXAuaWlkOjQ5MDk5MTU4LWJkMWEtMjQ0OC04ODU0LWI4MzY4NWFjNDcyNyIgc3RFdnQ6d2hlbj0iMjAyMi0wMy0yNFQxNTowMDozMSswNTozMCIgc3RFdnQ6c29mdHdhcmVBZ2VudD0iQWRvYmUgUGhvdG9zaG9wIDIzLjEgKFdpbmRvd3MpIi8+IDxyZGY6bGkgc3RFdnQ6YWN0aW9uPSJzYXZlZCIgc3RFdnQ6aW5zdGFuY2VJRD0ieG1wLmlpZDplZWFjZmJiZS0xYjg4LTE4NDItYmNjYS00YTM5OTUyMGFlODEiIHN0RXZ0OndoZW49IjIwMjItMDMtMjRUMTU6MjQ6MzQrMDU6MzAiIHN0RXZ0OnNvZnR3YXJlQWdlbnQ9IkFkb2JlIFBob3Rvc2hvcCAyMy4xIChXaW5kb3dzKSIgc3RFdnQ6Y2hhbmdlZD0iLyIvPiA8L3JkZjpTZXE+IDwveG1wTU06SGlzdG9yeT4gPC9yZGY6RGVzY3JpcHRpb24+IDwvcmRmOlJERj4gPC94OnhtcG1ldGE+IDw/eHBhY2tldCBlbmQ9InIiPz4Ae+38AABVZUlEQVR4nO3deZgcZaG28bt6ZrJOCEkIISEkkEzCjuz7JiCoKIgLqKCiiIoKLh8irhxcOHo8rojocQEOIqjIdgTZUUEFkWAiBGEmCSFASEL2fZau74/KxBCz9MxU11vVff+u671IZobU0zXT3c/U8r4RkiJgIDAI6L/u7xtbCywGOjPMVc8GANtt5nNlYB7QlV0crdMPGAw0AY1AieT7sRpYAsTBkkmBxXHy498YOIeUtYHAa4HDgf2BCcBokkK1NV3Ak8CDwI3AH/CNJA0NwKHAccDBwD7AWJI37c1ZC8wApgIPAfcArdWNWTcGA0cAhwF7kzxHxgDDSIrV5qwl+R48DtwL3AG8XNWkkqRg9gGuAZaTlKE0xlPAOSTFQD23H3AlsIB0vh+PAx8jKQbqueOAXwIrSef70QH8Bnh1lg9CCiWO4/VHraRaNhK4iuRoU1qFauPxD+DorB5QDTgYuIvqfT/mAxfgEflKHQb8hep9P2KSI1ivyuoBSSFYrFQPTgReorpvGN2jC/gOWz5VUu+GkxyhqmbJ3XD8DZiYySMrpgEkP7NZfT86gP/AwqsaZbFSrfs02b1hbDgeAkZl8PiK5hTgBbL/frwMHJXB4yuaMcAjZP/9iIEHSK7XkmqKxUq1qgRcQZg3jO7RCoyv9gMtkFOBNYT7fqwiuWFBiYnATMI+R6YD46r9QKUsWaxUi0rA1YR9w+ges4Adq/poi+FwYCnhvx9rgdOq/FiLYBzwLOG/HzHwNB7dVQ2xWKkW/YDwbxYbjr8D21TzAefc3uSjVHWPDuCkqj7ifBtCMj1F6O/DhuNRkmu9pMKzWKnW/D/Cv0lsavyqmg86x3YAZhN+/288lgC7V+9h59oNhN//mxo/rOaDlrJisVItOZJkRvTQbxCbGx+s3kPPpQbg94Tf75sb06i/oyRnEn6/b2mcUr2HLmXDYqVaMZhkBu7QbwxbGkuor+utPk74fb618a1qPfgcGkqyBFDofb6lMRtortYOkLJgsVKtuITwbwqVjP+t1g7ImVHk67qqzY0OYK8q7YO8+Rrh93cl49Jq7QApCxYr1YLtSXeJmmqOTurj2p5vE35fVzr+r0r7IE+GA8sIv68rGUvX5ZUKyWKlWvBFwr8Z9GT8uDq7ITe2BVYQfj9XOsrAntXYETlyMeH3c0/G56qzG6Tqs1ip6BoJM5N3X8Zyanv6hQ8Tfh/3dFxelT2RDxHwT8Lv456MWSTz0UmFY7FS0R1H+DeB3ox3VmNn5MQfCL9/ezpepHbfyPcl/P7tzTi+CvtCqrruYlWrLyiqfUW9PbtWl1YZSjLLetGMBg4MHaJKivqzdmroAFJfWKxUVK8JHaCXanVB4ENJTs8W0WGhA1TJkaED9NIbQgeQ+sJipSIaAuwWOkQvjSfJX2v2Dx2gDw4KHaBKijqdxC7AmNAhpN6yWKmI9qW4P7sRMDF0iCrYNXSAPqjF70c/kgWXi+qQ0AGk3irqm5Pq24TQAfpoaOgAVVDkN/HxoQNUwVCSEl9UtT4NhmqYxUpFVOQ3cajNU4HbhQ7QB9uHDlAFRV8eZpfQAaTeslipiHYIHaCPavF5V+T5uRpITp3VkqL/jO0UOoDUW0V/8qk+DQodQP+m6MXEn6l8KXJRV52zWKmIBoYOoH9T9NeSok4VUassuiqsor8Yqj4V/eiIpC3zOa7CslhJkiSlxGIlSZKUEouVJElSSixWkiRJKbFYSZIkpcRiJUmSlBKLlSRJUkosVpIkSSmxWEmSJKXEYiVJkpQSi5UkSVJKLFaSJEkpsVhJkiSlxGIlSZKUEouVJElSSixWkiRJKbFYSZIkpcRiJUmSlBKLlSRJUkosVpIkSSmxWEmSJKXEYiVJkpQSi5UkSVJKLFaSJEkpsVhJkiSlxGIlSZKUEouVJElSSixWkiRJKbFYSZIkpcRiJUmSlBKLlSRJUkosVpIkSSmxWEmSJKXEYiVJkpQSi5UkSVJKLFaSJEkpsVhJkiSlxGIlSZKUEouVJElSSixWkiRJKbFYSZIkpcRiJUmSlBKLlSRJUkosVpIkSSmxWEmSJKXEYiVJkpQSi5UkSVJKLFaSJEkpsVhJkiSlxGIlSZKUEouVJElSShpDB5Dq0PbAzqFDpKwhdIA+2gloDh0iRWNDB5DqlcVKyt6PQwfQv5kSOoCk2uCpQEmSpJREoQNIm7E9sBcwARgHjAKGAwOAg9d9XlJtWgX8HlgBzAfmADOAf6z7b1ewZNJmxHEMWKyUD/1IytLRwCHr/rxD0ESS8moV8Dfgz8BDwB9ICpgUlMVKoY0FTgFeB7waGBw2jqSCagceBm4HfgtMDxtH9cpipRB2AN4BnE5yZMqfP0lpewa4EfgN3pSgDFmslJWBwKnAu4AT8U5USdl5Cvg5cB0wO3AW1TiLlaptIvBh4H3AtmGjSKpzZeBekqlObgU6wsZRLbJYqRoi4CTgfOC1OJ2HpPyZB1xDUrLaAmdRDbFYKU0NwBnAZ0imSJCkvCuTXOz+bZKpHaQ+sVgpDf2B9wAXkZz6k6QimkJSsH5Fcpeh1GMWK/VFI3A28EWSNdYkqRbMBr4GXAWsDZxFBWOxUm+USKZK+BIwKXAWSaqW54GvAz8B1gTOooKwWKmnTgD+C9gvdBBJyshzwOeAX5BckyVtlsVKlWoBvkkyS7ok1aPHgAvxIndtQXex8nZ4bc42JIfCn8BSJam+HQA8AFwP7Bg4i3LOI1balNNJ7pAZEzqIJOXMcuA/gO8BnWGjKE88FahN2QW4gmRhZEnS5v0d+ADwaOAcyglPBWpDjcCnSU77Waokaev2Bf4CfAdoDppEueIRK+1OsrzDQaGDSFJBzQTeT3IdluqUR6zUQDJj+hQsVZLUFxOA+4AfAIMDZ1FgHrGqTxOA/wWOCB1EkmpMK/Au4JHQQZQtj1jVrzOBx7FUSVI1TAIeIrlzsDFsFIXgEav6sQ3JHX9nhQ4iSXXiTyS/zM4OHUTV53QL9WU/4NfAxNBBJKnOLCZZtP62wDlUZZ4KrB/vIfmtyVIlSdkbBtwCfJXkpiHVOI9Y1a5+JGv8fTR0EEkSAHcDbyc5iqUa46nA2jYKuAk4PHQQSdIrPEOy/urToYMoXZ4KrF17kswGbKmSpPyZDDwMHBc6iKrDYlVbXktyPdUuoYNIkjZrW+B3eJd2TbJY1Y5zgf8DhoYOIknaqn4kEzVfFDqI0mWxqg0XAz/CyegkqUgi4OvAf+I1zzXDb2SxdT8pPxU6iCSpT64EPgLEoYOod7ovXvcIR3FFJAt+fih0EElSn51H8rr+YSxXheapwGKKgO9iqZKkWvIhkl+YPZtUYBarYvpv4PzQISRJqfsQ8F+hQ6j3LFbF80Xgk6FDSJKq5kLgc6FDqHc83FgsZwM/w++bJNWDc4GfhA6hyrikTfGcRDJPVVPoIJKkTHQCbwJuD5xDFbBYFcs+wEPAkNBBCmAxMBuYAywElgDLgXZgLd5tI2UpAvqvGwOBEcAO68aOwMhw0QpjJXAM8FjoINoyi1VxbAf8FZep2VgH8HfgUZIXnOkki5q6arxUHMOAXdeN/YGDgf1Iipj+5XmSfTM3dBBtnsWqGBqBu3CxTkiOND0O3Ak8QLLQ9MqgiSRVQz/gUOB44ASSQuGci8kv2McCqwPn0GZ0Fyvl23dJCkW9jk6SEvUhYHQf96WkYhoBvI/kOqPu0/n1Oq7u265UNcVxbLnKuXcQ/kkcavyTZP3DHfu8FyXVkuHAR0lO/4d+nQo1nMMwpyxW+TYJWEr4J3CWoxO4leTQv6eoJW3N/sBVwBrCv35lOdqBI1PYf0qZxSq/+gNTCP/kzWqsJll8tCWNnSep7owCLgUWEf71LKvxPN5RmTsWq/y6nPBP2izGWuAKPN0nKR3bAv9Bcmdw6Ne3LMaduHpKrlis8um1QJnwT9hqjjJwHbBzOrtMkl5hGPAN6uMU4adT2mdKgcUqf4YDLxD+iVrN8ReSW6clqdomAL8m/OteNUc7cFBaO0x9Y7HKnxsI/ySt1ngZeD8etpaUvROAVsK/DlZrPAM0p7a31GsWq3x5O+GfnNUa1wPbp7erJKnHBgJfJTnCE/o1sRrjf9LbVeoti1V+jADmE/6JmfZYALw5xf0kSX11IMnyV6FfH9MeZeCkFPeTesFilR9XE/5Jmfa4E2dKl5RPA4HvUHs3Cs0Bhqa3m9RTFqt8OIHaenJ3kMyY7rVUkvLuVGpv7qsrU91D6hGLVXgDgTbCPxHTGnNxNmBJxbIzyeLGoV8/0xpdJAtYKwCLVXiXEP5JmNb4CzAm3d0jSZkYAFxD+NfRtMbfgcY0d5AqY7EKazywkvBPwDTG9SQvTJJUZBeRrFka+jU1jXFeyvtGFbBYhfUrwj/x0hhfwQWTJdWONwGrCP/a2texgGSJH2XIYhXOqwn/pOvr6AI+mvaOkaQcOIrauKj9m2nvGG2ZxSqMEjCF8E+4vowO4J1p7xhJypG9SW7ICf1625exBtdkzZTFKox3Ev7J1pexFnhL6ntFkvJnV+B5wr/u9mVcnfZO0eZZrLLXD5hB+Cdab0c7yfUHklQvJgHPEf71t7ejE9gz9b2iTbJYZe98wj/Jejs6gLemv0skKfcmAy8R/nW4t+NX6e8SbYrFKluDgXmEf4L1ZpSB96a/SySpMPYFlhD+9bg3owuPWmXCYpWtCwn/5Ort+FQV9ockFc2RFHcqhuursD+0ke5i5RxE1TcQmAWMCh2kF66gfqZVKI0dO3bbAQMGDGpvb+9XKpWa4jj2+SFtJIqiOI7jtQ0NDava29uXP//886tDZ8rQGSQlpWivDV3AHsAzoYPUsu6jVUX74Siij5GspF40dwCnkDwha8KIESOGDB069FVRFO0LTIyiaEIURbvEcTwqiqIRURQ1hM4oFU0cx8uiKHoReKGrq6s1iqKn4zh+Ooqif7S1tT0fOl8VXAz8Z+gQvfAj4EOhQ9Qyi1U2+pPcCbhj6CA99E+ShTyXhg7SF+PHj9+hqanpBOCoKIqOAnaNoqgUOpdUL+I4ngc8Xi6X/1oulx9ctWrVX+bNm7cydK4UXAO8O3SIHuqe12pe4Bw1y2KVjXOAn4QO0UNLgYMp6CHjcePGTWhqajojiqJToig62CIl5Uccxx3AX8vl8h1dXV23P/vss1NDZ+qlgcCfgP1CB+mhLwNfDB2iVlmsqi8CpgF7hQ7SAzHJtAo3hQ7SE2PHjh04YMCAt0dRdDbJ0Sl/rqUCiON4BnB9e3v7L2bPnv1U6Dw9tAvwN2B46CA9sADYiWSyZ6XMYlV9rwHuDh2ih74NfDJ0iEqNGzdudFNT08dKpdL7oygaETqPpN6Jk3eku8rl8n/NmDHjgdB5euAU4BaK9V76HuB/Q4eoRRar6rsDeF3oED3wOMl1Ve2hg2xNS0vLWODTwPtLpdKA0HkkpSeO4zvb29s/M3v27L+HzlKhHwDnhQ7RA4+SXO6hlFmsqmtX4CmKs39XAQeQXLSeWxMmTBhaKpUuBj5uoZJqVxzH5XK5fHVnZ+fnZs+e/VLoPFsxkKSsFGkSzoNJMitF3cXKC3ur41yKU6oAPku+S1U0YcKEsxsaGlpLpdLFliqptkVRVGpoaHhf//79n5k4ceIngcbQmbZgNcnptc7QQXrg/aED1LIivfkXRT+SFdFHhg5SoQeBY0mWrsmdCRMmTGpoaPhRFEWvDp1FUhhxHP+9q6vr3JkzZ/4tdJYt+E+SOa6KYBkwBqiFqS9ywyNW1fMmilOq1pIcXctjqYpaWlo+1NDQ8LilSqpvURTt29DQ8JeWlpb/JPnlNY8uJd9H/je0DXB66BC1yiNW6bsHOCF0iAr9B8mLQa6MHTt2eP/+/a9uaGh4Y+gskvKlXC5P6erqesesWbPyONfe8cC9oUNU6PeAv7SmyIvXq2Mn4FmKcSRwJsnFlmtCB9nQxIkT929oaLiRZI4YSdqU5XEcv7e1tfU3oYNswg0kawrmXZlkJvY5gXPUDE8FVsfpFGeffpL8larToyj6E5YqSVs2BPh1S0vLV8nfa+6FwIrQISpQAt4ROkQtytsPZNG9PXSACt0P3Bo6xIYmTpz42VKpdIN3/EmqRBRFUalU+uykSZOuHz9+fJ5eN54HvhU6RIXeGTpALfJUYHpagNbQISoQAwcBj4UOsk40adKk70RRdEHoIJKKKY7jP8Zx/Ma2trZlobOssw3QRjFuZJpEklV95KnA9BXlDosbyU+papg0adJPLVWS+iKKoqOBe8aNGzcsdJZ1lgFfDR2iQqeFDlBrPGKVnkfI/zIBZWBf4B+BcwCUJk+efBXw7tBBJNWGOI7/tmTJklcvWLAgD9c4DSC5SWh06CBb8TBwWOgQtcAjVunaHjgwdIgK3EI+SlXU0tJyJZYqSSmKoujAbbbZ5jfkY66rNRTjWqtDgB1Ch6glFqt0vJZi7Mtvhg4AMHny5P8ulUofCJ1DUu1paGg4cdKkSVeTj9fkHwGLQofYigg4KXSIWpKHH7xacHLoABV4BPhz6BAtLS1fJJnqQZKqIoqid0ycODEPv0guJylXeffa0AFqiddY9V0DsADIy0WTm/Mu4OchA0ycOPGjDQ0Nl4fMIKl+lMvli9va2r4eOMY4kmutGgLn2JKFwCigK3SQIvMaq/TsS/5L1VIg6AzFLS0tbyyVSt8JmUFSfYmi6D8nTpz4nsAxniNn8wZuwgjgVaFD1AqLVd8dEzpABW4AVofa+MSJE1uAa6MoyvNvbJJqzLpJRH8yYcKE4wNHKcLpwKNDB6gVFqu+Ozx0gApcE3DbTVEU/bJUKg0NmEFSnYqiqLGhoeHqwHNc3Qe8EHD7lbBYpcRi1Xd5n/9jDsk8JUFMmjTpi6VSaf9Q25ekKIrG9u/fP+TF7F3AdQG3X4kj8brrVFis+mbMupFnN5IsY5O5CRMm7A18OsS2JWkjZ7e0tIS8dCPvxWoksHPoELXAYtU3+4UOUIEbA203amhouDKKoqZA25ek9aLElUCo16RpwIxA267UAaED1AKLVd/sEzrAVrxMoNOALS0t74yi6IgQ25akTYmiaPeJEyd+LGCEWwJuuxIWqxRYrPpm99ABtuJukvUBM9XS0tI/iqKiLEAqqY40NDR8cdy4caHW78v7tAt5P1hQCBarvtktdICtuDPQdj8URdH4QNuWpC0Z0q9fvy8H2vbDJLOx59WuoQPUAu8A6JuXSSZWy6OYZFX1eVludOzYsQMHDhw4M4oiF/WUlEtxHHd1dXXtN3PmzBCL0t8OvD7AdivRBQwC2kMHKSJnXu+7IeS3VAG0knGpAujfv//7LVWS8iyKooYoir4YaPMPBNpuJRqAiaFDFJ3FqvfyPs3CnwJss7GhoeETAbYrST1SKpXe3NLSskeATYd4be6JHUMHKDqLVe/l/ajMQ1lvsKWl5TRgl6y3K0k9FUVRKY7jjwbY9FSgM8B2KxXqwv6aYbHqvTyfBgR4JMA2Pxxgm5LUK6VS6V0tLS3bZLzZVcD0jLfZExarPrJY9V7WT8aeWAs8neUGx48fv1sURUVYkFqSAIiiqDmO4zMCbPrvAbZZqZBrKtYEi1XvDQ4dYAueIuNDzY2NjWdHUeRdppIKpVQqnRVgs88E2GalBoQOUHQWq97L81It0zLeXinQi5Mk9dVREyZMGJfxNlsz3l5PDAwdoOgaU/y3xgEHksxGPp7kGqRtgP7U5nxZeb5z4p9ZbmyXXXY5IoqiPO8PSdqkKIqihoaGNwHfy3CzbRluq6feBOwZOkQVxCSXyawEFgHPkRw5nEJy6Uyc1ob6Uqwi4FjgDOAkXBU7TzJd6LOxsfGtWW5PklJ2KtkWqxcz3FZPjVo36sl84B7g18Dv6OMEqb05kjQQOBe4ACcSy6vDgb9ktbHJkyfPxGkWJBVUHMedcRyPaGtrW5bRJhtJjp54OU7+zAd+SFK0F/bkf+ztzOunk5xm+i6WqjzL7Leh8ePH746lSlKBRVHUCGR5V3MnPXzTVma2B75Icrr2E/TizF6lxWo4cAvwS5JrqZRvmT1hm5qaXp3VtiSpWuI4Pi7jTS7JeHvqmW2Bb5HMlD+hJ/9jJcVqd5LJJk/tcSyF0ElycV4mnLtKUi0olUpHZbzJNRlvT71zMPBXoOLivbVidSDwZ6ClD6GUrbWkeHdDBQ7JcFuSVBVRFO3d0tLSP8NNrs1wW+qbEcCdwFsq+eItFatXAXeRHA5TcXRktaHRo0dvF0XR+Ky2J0lV1K+rq+tVGW7PYlUsTcD1wBu39oWbK1YjgdtIrq1SsWR2tKq5uTnEyvCSVBUNDQ17hc6gXGsCfgFs8edkU1e7R8B1eJG6tqJcLu/a0NAQOoa2YMiQIYwYMYJtt92WwYMH09zcTHNzM4MHD6Zfv37069ePxsZGGhoaaGpqIo5jOjs76ezspKOjg87OTlatWrV+rFy5kqVLl7J06VIWL17MypUr199iLNUA73bX1jQDNwH7sZnrmTdVrN4HvKaKoVQ7nG09oCiKGDNmDBMnTmTcuHGMGTOGsWPHMmbMGLbffnuGDx9OU1N1V17q7Oxk4cKFzJs3j/nz5zN//nxeeOEFnnvuOWbPns2cOXNYtWpVVTNIKerR3V+qW5OALwOf3NQnNy5Ww4FvVDuRakOpVNohdIZ6MXjwYPbYYw/22msv9tprLyZOnMguu+zCgAFh10ttbGxk1KhRjBq1+Yma586dyzPPPENraytPP/0006dPZ8aMGR7pUu6USqWRoTOoMC4ArgGmbvyJjYvVhcCwLBKp+OI4HhxFtbgMZHjbbbcdhxxyCAcffDAHHXQQEyZMoKj7evTo0YwePZpjjvnXzBwrVqzgiSeeYNq0aTz88MM89thjrFnj3ecKbpvQAVQYDcCX2MRUVBu+Um8LzCE5f6jiWkxGNx1MnDjx1w0NDa4TmIJSqcSrXvUqjj32WI477jgmT54cOlKmOjo6mDp1Kn/+85954IEHeOqppzyipczFcTy9tbU1qwWIHwKOyGhbqo4Y2B/4O/xrSZsNj1i9G0uVeqBUKhXzEEpORFHEQQcdxMknn8xJJ53EsGH1e7C4qamJAw88kAMPPJALLriAefPm8cADD3D77bfz6KOPWrKUFV/T1BMRcB7wwY0/2G0asHeWiVQVmR2xmjRp0o1RFFU0YZr+ZaedduKMM87glFNO2eK1SUrMnz+f22+/nRtvvJG2trbQcVTD4jh+qrW1NatpZDxiVRtWAKOAVd2/AHYXqxagNVAopctilUNRFHHsscdy5plncuSRRxb2eqnQHn/8cX75y19y++23097eHjqOaozFSr10KnDbxqcC3xAsjlTDGhoaOPnkk/ngBz9IS4srQ/XVfvvtx3777ceFF17Itddey/XXX8/SpUtDx5JU395AMqk68K+Z123NUoqiKOJNb3oTd911F9/4xjcsVSnbbrvt+MQnPsHvf/97PvGJT7DNNt7MJSmYV3So7mJ1cIAgUk068sgjufnmm/n617/OTjvtFDpOTRs0aBAf+tCHuP/++znvvPPo3z/LNXQlCYDdgKHdfykBgwFf/aU+2mGHHbjiiiv46U9/yu677x46Tl0ZMmQIH//4x7njjjs48cQTQ8eRVF9KwOQN/7IL3mIq9VoURbz73e/mjjvu4IQTTggdp66NHTuWyy+/nB/96EfssIMLA0jKzPrlkEqArz5SL40aNYqrrrqKz33ucwwePDh0HK1z7LHHcvvtt/OWt3jTqqRMrJ87pwQMCRhEKqzjjz+e2267jcMOOyx0FG1Cc3Mzl112Gd/+9rdpbnbuY0lVtf4OmhIQdhVXqWCiKOL888/nBz/4Adtuu23oONqK17/+9dx0003suuuuoaNIql3r75wpAWsDBpEKZdCgQVx++eV89KMfDR1FPTB+/HhuuOEGjjvuuNBRJNWm9TMWl4DVAYNIhTFs2DCuueYaXvOa14SOol4YNGgQP/jBD3jPe94TOoqk2rO+S5WAuQGDSIUwevRofvGLX7DPPvuEjqI+iKKIz372s3zkIx8JHUVSbVnfpUrA8wGDSLk3atQorr32WiZMmLD1L1YhXHDBBVx44YWhY0iqHeu7VAl4GZgfLouUX8OHD+fqq692BvUadO655/LhD384dAxJteHJ7j90L2nz9zA5pPwaPHgwP/vZzzxSVcM+9rGP8c53vjN0DEnF9gLJQSrgX8XqwTBZpHwqlUp861vfcmmaOvD5z3+eI45wHXpJvfaKDtVdrO4JEETKrYsuuohjjz02dAxloKGhge985zvsvPPOoaNIKqa7N/xLd7F6FC9ilwA46aSTeO973xs6hjK0zTbb8L3vfY9+/fqFjiKpWDqA3274ge5iVQZ+nnkcKWd22mknLrvsstAxFMCuu+7KxRdfHDqGpGK5E1iw4QdKG/z5J0BXpnGkHGloaOBb3/qW68rVsTPPPJOjjz46dAxJxfHDjT+wYbGaAfw6uyxSvrz3ve91AlBx6aWXMmjQoNAxJOXfNOB3G3+wtNHfLyU5XyjVlfHjx3PBBReEjqEcGDNmDB//+MdDx5CUf18A4o0/uHGx+ifwvUziSDly6aWX0r9//61/oerCWWed5fxlkrbkTuC2TX1i42IFcAnwdFXjSDly/PHHc9hhh4WOoRxpaGjgU5/6VOgYkvJpCfChzX1yU8VqJfBOYE2VAkm50dTU5J1g2qTjjjuOAw44IHQMSfkSAx8AZm/uCzZVrACmAO8imYZBqllnnHEG48aNCx1DOeVagpI28kW2cqPf5ooVwI3AB3EKBtWofv368YEPfCB0DOXYkUceyV577RU6hqR8+G/gK1v7oi0VK0jmtnorsCqNRFKevPWtb2XUqFGhYyjn3ve+94WOICmsMnAhUNGFl40VfM0twKHALwB/dVNNKJVKvP/97w8dI6jOzk5WrlzJ6tWr6ejoII5joiiisbGRpqYm+vfvT3NzM1EUhY4a1Iknnsh2223Hyy+/vPUvllRrXgTey0brAW5JJcUK4B/AgSSN7SJgmx5Hk3LkuOOOY8cddwwdo+rmz5/P9OnTaW1tZdasWbzwwgu89NJLLFy4kBUrVhDH/zYFyytEUURzczNDhw5l1KhRjBkzhtGjR7PLLruw22670dLSUvPr6zU1NfG2t72NK6+8MnQUSdlpB35EMlPC4p78j5UWK4C1wFdJpm//MMlV8WN7sjEpL84666zQEapi9erVPPTQQzzwwAP89a9/Zc6cOX369+I4Zvny5Sxfvpznn3+exx577BWfb2hoYLfdduOwww7j8MMP5+CDD6apqalP28yjN73pTRYrqT4sBv4X+A7wbG/+gb4c428AjgBOAo4C9gGG9uHfUzoWA8Oz2NCkSZNujKLoLVlsK00TJkzgd7/7t1UICu3xxx/nuuuu495772X16tXBcjQ3N3PiiSfyxje+kcMPPzxYjmp4y1vewhNPPBE6hqoojuOnWltb98hocw+RvIcqrFXAE8BfgHuA++jldFPdZwB6csRqY13AH9eNbtsBI4HBffy38+5LwGtCh1DvnHrqqaEjpOYPf/gDV1xxBVOnTg0dBYAVK1Zw0003cdNNN7Hzzjtzzjnn8OY3v5nGxuK/HJx88skWK9WLNpIpl2pVJ0l5ehmYxyaWpemL+r4qtfeuB94eOsRmeMRqC6Io4v7772fMmDGho/TJnDlzuOSSS/jTn/4UOspW7bzzznzuc5/j6KOPDh2lT5577jle8xp/n6plHrFa7x8kZ6HUA91HrLY23YJUUw466KDCl6obbriBN7zhDYUoVQDPPvss5557LhdddBErV64MHafXxo0bxy677BI6hqScs1iprpx44omhI/RaR0cHF198MZdccglr1hRvxalbb72Vt771rTz33HOho/TaMcccEzqCpJyzWKluRFHECSecEDpGr7S3t3Peeedx8803h47SJzNnzuSMM87g6aeLuc77oYceGjqCpJyzWKlu7L777owePTp0jB7r6uri/PPP58EHHwwdJRWLFi3i7LPPZvbsza5hmlv7779/3U+YKmnLLFaqG0U9jfPlL3+Z3//+96FjpGrRokV88IMfLNw1V0OHDmXixImhY0jKMYuV6sYhhxwSOkKP3XrrrVx//fWhY1TFrFmzuPTSS0PH6LF99vFmKUmbZ7FSXejXrx/7779/6Bg9Mm/ePL70pS+FjlFVt956a+FOce6+++6hI0jKMYuV6sK+++5L//79Q8foka9+9ausWLEidIyq+9rXvka5XA4do2K77bZb6AiScsxipbqw3377hY7QI4899hh33XVX6BiZaGtr44477ggdo2KTJk0KHUFSjlmsVBf23nvv0BF65Hvf+17oCJm6+uqrQ0eo2LBhwxgyZEjoGJJyymKlulCkC46ffPJJHn744dAxMvWPf/yjUHNbjRs3LnQESTllsVLNGzlyJKNGjQodo2LXXXdd6AhB/O53vwsdoWI77bRT6AiScspipZpXpGtiVq1aVaiCkaYHHnggdISKbb/99qEjSMopi5VqXktLS+gIFfv973/PqlWrQscI4umnn2bx4sWhY1Rk5MiRoSNIyimLlWpekWbKvvfee0NHCCaOY6ZOnRo6RkW222670BEk5ZTFSjVvwoQJoSNUJI5j/vSnP4WOEdRTTz0VOkJFtt1229ARJOWUxUo1b+zYsaEjVOSpp55iyZIloWMENWPGjNARKtLc3Bw6gqScagwdQKqmhoaGwtwROGXKlNARgpsxYwYzZ87MbHulUolSqUQURTQ0NNCvXz/69+/PgAEDaGpq2uz/Z7GStDkWK9W0HXbYgYaGhtAxKjJt2rTQEYKbPn06r3vd60LHAKCxsZHBgwfT3NxMc3MzQ4YMYcSIEYwYMSJ0NEk5ZrFSTRs9enToCBUr0gSZ9aCzs5OlS5eydOnS0FEkFYjXWKmmFeXoQldXV2GuL5IkbZ7FSjVt+PDhoSNU5MUXX6SjoyN0DElSH1msVNOKcsRqzpw5oSNIklJgsVJNK8oRq5deeil0BElSCixWqmlFuS1+/vz5oSNIklJgsVJNGzRoUOgIFVm0aFHoCJKkFDjdgmra4MGDQ0eoSN5v6V85+VAWHf2u0DFyacCcJ4g62wEodbYz4Lkn13+uccVC+i2YHSqapAAsVqppRSlWy5cvDx1hizqbh7N6wn6hY+RSJfslWle4SmuW039uK02L59K0+CX6z32GhjUrMkgpKSsWK9W0fv36hY5QkdWrV4eOoCqKG/utL2Ar9zj6FZ9rWLGIQTOnMGDOkwx47gkGznlyU/+EpIKwWKmmNTYW40d8zZo1oSMokK7m4Szf5wSW73MCkBzdGjhzCs1PPciQqfd4REsqmGK860i9VJR1Ajs7O0NHUE7Ejf1YNflQVk0+lPmnforB0//IkGn30jz9j5TWXcslKb8sVqppRTli1dXVFTqCcmrlHkezco+jKa1ZQfP0PzL0kZs9XSjlWDHedaReKpWKMaNIHMehIyjnygOaWbb/61m2/+sZOPNxRtz3UwbNmhI6lqSNWKwkqWBWT9iP5yd8n4EzH2fk7d9hwNzW0JEkrVOMX+clSf9m9YT9eO78a3jhrK+xZvSk0HEkYbGSpMJbucfRPHf+Ncw79VOUG4sxxYhUqyxWklQjlh5yGrPPv4b2keNDR5HqlsVKkmpIx8jxzD7/GpYcclroKFJdslhJUo2JG/sx/9RP8fzZ36JrQHPoOFJdsVhJUo1aNflQnv3kDV7YLmXIYiVJNayreTjPn3sFKycfGjqKVBcsVpJU48oDmnnxrK+xbN16hJKqx2IlSXUgbuzHS2//Ekv3f33oKFJNs1hJUh2Z99bP8/Lx54SOIdUsi5Uk1ZlFx59juZKqxGKlmubixtKmLTr+HOe6kqrAYqWa1tXVFTpCRRobXQ9d2Vtw8se8W1BKmcVKNc1iJW1e3NiPuW//kkvgSCmyWKmmFaVYNTU1hY6gOlUe0OwM7VKKLFaqaR0dHaEjVMRipZA6h43mxbO+TrmxX+goUuFZrFTTVq9eHTpCRQYPHhw6gurc6gn7seDkj4WOIRVeGhd2DAeOBQ4G9gLGA9sDzUATEKWwjbxpCB1AlVm1alXoCBUZOnRo6AgSSw85jSHT7mPQrCmhoyisvYBiHO7vuU5gFbAAmANMBx4FHgBeSGMDvS1WA4C3A+8Cju7DvyNVlcVK6pmX3vo5dv72Oyh1toeOonAiavd9vZGkwwwHdgW613mKgceA64BrgMW93UBPTwUOAC4EZgNXAcdRuztfNaAoxWrbbbcNHUECkuutPCWoOhQBBwLfJjmS9Q2S8tVjPSlFxwP/A0zozYakEBYv7vUvHZkaNWpU6Ai517h4LhO+8ZaqbmP1TnsSN/bf5OfKA5tZM3rSv752l/3Xf3ztBh+vBZ4SVJ0bTHIQ6X3AJ4D/7cn/XEmxKgFfBi7Gi91VMEUpVjvuuGPoCAIGznlyi59vnv7HDf7201d8rmtAM2tHT2bNuD1ZO3oSKycfSrnAUxh4SlBiOMlpwdcC5wAV3Q21tWI1YN0/enqfokmBWKyUlYY1Kxg0a8orjvKs3mlPVuxxNKsmH1q4o1qdw0bz8knnsf3t3w0dRQrtHSRn604B5m/ti7d0BKoJ+DWWKhXYwoULQ0eoyPbbb0///ps+BaXiGjjnSUbedSXjL38P4y5/D9tMuYOoQEeAlh5yGp3NvbrMRKo1hwD3AMO29oVbKlb/A7whrURSCPPmzQsdoSJRFDF58uTQMVRFA+a2ssONX2HCZW9g5O3fpbRmRehIWxU39mPBGz4eOoaUF/sA/wds8bfgzRWrDwFnpxxIytzcuXNDR6jYnnvuGTqCMtCwZgXD/vRLdv7W29lmyh2h42zV8n1OeMVF+1KdOwL47y19waaK1W4ktxtKhbdkyRLWrl0bOkZF9thjj9ARlKHGFYvY4cavsNOV59K0YHboOFu08PhzQkeQ8uSjbOGM3sbFKgJ+QHLRulR4cRzz/PPPh45RkX333Td0BAUwcM6TjLvyXAa/4o7DfFm5x9EetZJe6XJg0KY+sXGxehPw6mqnkbL07LPPho5QkcmTJztRaJ1qWLOCHX9+McPv++nWvzgQj1pJr7Az8MlNfWLDYhUBX8gijZSlohSrKIo46qijQsdQQNvd91NG3fiV0DE2yaNW0r/5ODBk4w9uWKyOA/bLKo2UlZkzZ4aOULETTjhh61+kmjZ0yh1sf+s3QsfYpCVHnBE6gpQnI4D3bvzBDYuVx3lVk1pbW0NHqNgxxxzDoEGbPG2vOrLtIzfn8rTg8n1OoKvAs8lLVfBv3am7WA0iub5KqjlPP/005XI5dIyKDBw4kNe97nWhYygHtrvvpwx95ObQMV4hbuzHsgNODh1DypN9gL02/EB3sToOGJh5HCkDa9asYdasWaFjVOzMM88MHUE5MfL279K4OF9zsS3b//WhI0h584onRXex8sIO1bQnn9zy4rp5sueee3LooYeGjqEcKHW2s8ONXw0d4xXWjp7kRezSK71mw790F6uDAgSRMjNlypStf1GOnH/++aEjKCcGzZqSu1OCSw9+U+gIUp4cSDKzApAUqwjYN1QaKQuPPfZY6Ag9cuCBB3LiiSeGjqGcGHn7d2lYsSh0jPWWHXAy5cZ+oWNIebEtsEv3X0rAKDYze6hUK1pbW1m2bFnoGD3yuc99juZm78BSckpw+B+uDR1jvbixH8v38QoSaQOvKFbjAgaRMhHHMY888kjoGD2yww478PnPfz50DOXE0EduztVRq9UT9g8dQcqT9V2qRHIIS6p5Dz74YOgIPXbaaafxtre9LXQM5UDejlqtnOwNFtIGtu3+QwlPA6pOFLFYAVxyySUcccQRoWMoB/J01Kqrebh3B0r/sr5LbbwIs1SzXnzxxULNwt6tqamJK664gsMPPzx0FAVW6mxnm8duDx1jvVUetZL+TQlYFTqElJU777wzdIReGThwIP/zP//DG9/4xtBRFNi2f70ldIT1Vk6yWEnrrO9SJWBJuBxStoparCA5cvXf//3ffOELX6B///6h4yiQpsVzGTjz8dAxAFgzbk+nXZASS7r/UALmhMshZautrY22trbQMfrkrLPO4tZbb+Wwww4LHUWBDP1rPiYMjRv7eTpQSqzvUiXgJTwdqDrym9/8JnSEPttll124+uqr+dGPfsTee+8dOo4y1jz9j0Sd7aFjALBql/1CR5DyYGb3H0pADPw9WBQpY7fccgsdHR2hY6Ti2GOP5cYbb+QXv/gFp5xyCgMHupZ6PSh1tjPguXysf7l29OTQEaTQlgCzuv/SuO6/jwLecqS6sGjRIu6//35OOumk0FFSc8ABB3DAAQewevVqHnnkER588EEeeughZs+eTRzHoeOpCga3PszqCeGPFq0d45QLqnt/IzlIBfxruoV7w2SRwrjmmmtCR6iKgQMHcuyxx/KFL3yBu+66i0cffZRrrrmGV73qVaGjKWWDnnk4dAQAygOa6WweHjqGFNI9G/6lu1jdD6zOPosUxmOPPca0adNCx6i6IUOGcOihhzJunCtX1ZoBc1sprVkROgYAa8btFTqCFNIdG/6lu1itAm7JPIoU0M9+9rPQEaQ+GThzSugIALSPHB86ghTKNOCJDT+w4czrvsuortx5552Fn3pB9W3gnLxcwO51Vqpb/9adNixW9+HdgaojcRzzve99L3QMqdf6LZgdOgKAawaqXi0Crtr4gxsWqxj4SmZxpBy4++67efLJfPzWL/VUXopVx8jxzsCuevRdYNnGH9x4EeabgD9mEkfKgTiO+cpX/H1CxZSXYgVeZ6W68xzwzU19YuNiFQPnAWurnUjKiylTpvDb3/42dAypV5pyUq4sVqoz5wMrN/WJjYsVwHTg/1U1jpQzX//611m+fHnoGFKP5eWoVdeQEaEjSFm5Erhtc5/cVLECuAK4tipxpByaP38+l112WegYUo/lpVg5SajqxMPAJ7b0BZsrVgDnAJ4fUd246aab+OMfvcRQxdK4YlHoCIBHrFQX/gGczFYul9pSseoA3gb8KsVQUq5dfPHFLFiwIHQMqWKl1fk4hd2x7ejQEaRqegQ4gWSKhS3aUrECWAO8A7iMDRYYlGrVwoUL+X//7/9RLpdDR5Eq0rT4pdARAOgc4qlA1awbgFcD8yv54q0VK4Ay8DngJGBm73NJxfDII4/wrW99K3QMqSJRZz5u4u4c5hEr1ZxFwHtJDjBVvJ5yJcWq2z3AXsBngJd7FE0qmB//+MfcfPPNoWNIW5WXa6zixn50DWgOHUNKwyrgO8Bk4Oqe/s89KVaQNLavAeOBc0kmE+3q6UalIvjCF77AI488EjqGtEUNyxeGjrCeF7Cr4P4OfAoYR3LnX6+eXI293Pgq4CfrxkjgGOBAYG9gArA90Aw0AVEvtyEF1dHRwXnnncfVV1/NPvvsEzqOtEmlznaiznbiHCwp09k8IjfTP0ib0UnSYeYDz5LM3fk3kgNFqfzw9rZYbWgBcOO6US+uB94eOoSqb+XKlZxzzjlce+217LbbbqHjSJvUsHxhLq5x6hi2A8wKnUIp+Afgb5O91NNTgVLdWbZsGe9+97uZNm1a6CiSpJyzWEkVWLp0KWeffbbXXEmStshiJVWo+7TgTTfdFDqK9AoNa1aEjiBpHYuV1AMdHR185jOf4Wtf+5qTiCo3SqvzUay8K1CyWEm9ctVVV/Hud7+befPmhY4i5UY5B3cmSqFZrKReevTRRznllFO49957Q0eRJOWExUrqgyVLlvCRj3yET33qUyxZsiR0HElSYBYrKQW33XYbr3/967n11ltDR5GCycMkpVJoFispJQsXLuSiiy7i9NNPZ+rUqaHjSJnz4nXJYiWlburUqZxxxhmcf/75PP3006HjSJIyZLGSqiCOY+6++25OPfVULrjgAp544onQkSRJGbBYSVUUxzF33XUXb3nLWzjrrLO49957nf9KkmpYGoswS6rAo48+yqOPPsqoUaM47bTTePOb38z48eNDx5JS07h4bugIUnAesZIyNm/ePH74wx9y0kkncfrpp3PVVVcxd65vSJJUCzxiJQUSxzFTp05l6tSpfP3rX2fvvffmmGOO4aijjmLvvfemVPL3HlWmPLA5dARJ61ispByI45hp06Yxbdo0Lr/8crbZZhsOPPBADjzwQA466CD22GMPGht9umrTugZYrKS88JVayqFly5Zx//33c//99wMwYMAAdt11V3bffXf22GMPdt99d3bZZReGDBkSOKn0L01eYyVZrKQiWLNmzfrThhvabrvtmDBhAjvvvDNjxoxh9OjRjBkzhu23354RI0ZYvCQpYxYrqcBefvllXn75Zf76179u8vP9+vVjxIgRLF++PONkypIznkv5YbGSalh7e7t3HNaBvKzRF3W2h44gBedtR5JUYB3DRoeOsF7j8kWhI0jBWawkqcDydEdg0xKPjkoWK0kqsPKA/Nyg0LB8YegIUnAWK0kqsM4hw0NHAKC0ZgUlr7GSLFaSVGTlgfk4YuXRKilhsZKkAutszscRKy9clxIWK0kqsI6R40NHALxwXepmsZKkAsvLdAuNLmcjARYrSSq09pwcsWpc4alACSxWklRYnc3DKedkHisXYJYSFitJKqi8nAYEGPDcE6EjSLlgsZKkglo7ZnLoCEByfVXDmhWhY0i5YLGSpIJq325c6AgA9J/bGjqClBsWK0kqqLWj83HEauCcJ0NHkHLDYiVJBVRu7MeacXuGjgFAvwWzQ0eQcsNiJUkFtGanvYgb+4WOAXjhurQhi5UkFdCqCfuFjgBAw4pFzmElbcBiJUkFtHqX/UNHADxaJW3MYiVJBZOn66sGtz4SOoKUKxYrSSqYFXscnZvrqwY/83DoCFKuWKwkqWCW7f/60BEAaFow26VspI1YrCSpQDqbh7N6Qj6ur/JolfTvLFaSVCAr9jwmN6cBm6c/GDqClDsWK0kqkOV7nxA6AgBRZzsD5nhHoLQxi5UkFcSa0ZNYnZP5qwY98zClzvbQMaTcsVhJUkEsPP6c0BHWGzLt3tARpFyyWElSAawZPYmVexwdOgaQzLbePP2PoWNIuWSxkqQCyMsUCwBDpt7jaUBpMyxWkpRz7SPHs/SQ00LHWG/bv94SOoKUWxYrScq5l976+dxMsTBw5uP0WzA7dAwptyxWkpRji484gzU75WNdQIChf705dAQp1xpT/ve2BUYBQ6rwb+fJiNABJNW+jmGjefmk80LHWM+L1uvGQODQ0CGqqBNYBcwHXk77H+9L+SkBRwAnrvvvPlg4JCkVXQOamfP+7+fmFCB40XodaQH+EjpERpYD/wAeAe4B7gP69EPem2I1Avgw8H5gXF82Lkn6d+XGfjx/7hV0DhsdOsoreNG6atAQ4PB14xPAIuBa4DvAs735B3tyjVU/4DPATOBLWKokKXVdA5p58ayvsXb0pNBRXmHItHu9aF31YDjwMeBp4Hsklzj1SKXFam/gb8BlwDY93YgkaetWTj6UZz95A6sm5+vylqiznZG//U7oGFKW+gHnA08Ar+nJ/1jJqcA3AtcDg3ueS5K0NeXGfsx/00W5mgR0Q0MfuZnGFYtCx5BC2BH4HXAhyenBrdpasTob+HEFXydJ6oXVO+3JS2/9PB0jx4eOsklRZzvD/3Bt6BhSSA3At0lmPfjM1r54S4XpNOAn6/5BSVKKOpuHs/iIM1h8zLtCR9kij1ZJ610MLAW+tqUv2lyx2he4DkuVJKVq2T4nsHKPo1m+zwmho2xVw4pFbHfXlaFjSHlyGdAK/GZzX7CpYjWY5JqqgVUKJUl1pX3keBYffjor9jyGrubhoeNUbPgfrnXeKumVIpJLpP4GbPI22U0Vq0uB3aoYSpJqWsew0bSPHM/qnfZk+T4n5Pb6qS1pWjCboY+4fI20CcOAHwKv29QnNy5WuwEXVDuRJBXN6p32JG7s/4qPdQ4ZTvu60rR6l/0BWDtmEuUBzZnnS9sON37Fo1XS5r0WOAW4beNPbFysLgGaskgkST3ROWw0z1z259Ax6sLw+37KwDlPho4h5d2Xgf8D4g0/uOEEoROBt2WZSJKULwPmPOn0ClJl9mETpwM3LFbvx7sAJaluRZ3tngKUeuZDG3+gtMF/z8w2iyQpT7a760rXA5R65rXAyA0/0F2sDgR2yjyOJCkXBs58nGF/+mXoGFLRNAEnb/iB7mLVowUGJUm1o3HxXEbf8IXQMaSiOnHDv3QXq6MCBJEkBVZas4KxV3/SZWuk3ntFh+ouVvtmn0OSFFLU2c6OV33C66qkvhkLbNf9l9K6v4wKFkeSFMSYn1/sfFVSOvbs/kOJpGlJkurIqBu/wuBnHg4dQ6oV67tUCRgdMIgkKWPD7/spQ6fcETqGVEt26P5DIzAwYBBJUoa2u+tKZ1aX0jeo+w+NQL+AQSRJGYg62xl141fYZtq9oaNItWh9l2oE1gYMIkmqsoYVi9jxqk8wYG5r6ChSrVrfpRqB5QGDSJKqqP/cVsb8/GKaFs8NHUWqZcu6/9AIvBQwiCSpSob94VpG3PdTF1WWqm9e9x8agVlADETB4kiSUtN/bivb3/JfzlElZWdm9x8agZXA87gIsyQVWtTZzoj7fupdf1K2ysAz3X9pXPffR7BYSVJhDZ7+R0bedaXL00jZexpY2v2X7mL1Z+CtQeJIknpt8PQ/MuK+n3rHnxTOnzb8S3ex+i3wreyzSJJ6w0Il5cZvN/xLd7FqBZ4A9so8jiSpYkOm3cuwP1xroZLyYSVwz4YfaNzgzz8Fvp1pHEnSVvWf28rQv97CkKn30LBmReg4kv7lemDVhh/YsFhdA3wFGJxlIhVXHMflKHKWDqkaGlYsYsjUe9j2r7d4QbqUX1du/IENi9Vi4PvApzOLo0KLomhl6AxSLRkw50kGzpzCoFmPM/iZh0PHqUdrQgdQofwWmLLxBxs3+vs3gA8C22YQSAUXx/Fyj1hJvRN1tjPguScZMOcJBs16nIEzpzhDemD+sqge6AK+sKlPbFysFgIXAf9T7USqCQtCB5DybuDMx5P/zppC44pF9Js/m/5zn/FaqRzq6upyiTdV6nLg75v6xMbFCuAnwNuA11QxkGrDjNABlI3GFYvWF4R6NmDOE0SbOarUb8FsGpcvArA4FdfzoQOoEFrZzNEq2HSxioEzgb8B46oUSjUgiiKLVZ0Y/MzDXvOjmhdF0TNb/yrVuRXAm9f9d5NKm/n4AuAUkgvaVSyZXfS0aNGi6XEcl7PaniRV2fTQAZRrHcA7Seb93KzNFSuAqcBJbLD+jQqhKasNLVy4cDnJGkmSVGjrfknM8nx3Zq/VSkUnydm8/9vaF26pWAE8ChwJzEwhlLLRP+Pt/S3j7UlS6uI4fqqtrW1Zhpu0WBXHYuD1wK8r+eKtFStIDnkdTAUtTbnQSIaTvJbL5Qez2pYkVdEfMt7eoIy3p975G3AIGy1bsyWVFCtIpmE4BXgH3jVRBMOz2lAURfdntS1JqqIHMt7ethlvTz2zFLgQOIzkLsCKVVqsut0ATAY+hqcH82x0Vhtqa2ubEcfxs1ltT5LSFsdxR7lcrviIRAoiYFiG21Pl5gNfAiYC3yS5tqpHelqsAFYD3wMmASeQTCbqUax8GZvlxuI4/m2W25OklD04c+bMLG/UGg70y3B72rKFJIspv5VkmqlL1n2sVzY1j1WlysB96wbABOBAYFdgJ2AU0ExygV4trnuyI7BL6BCbMTHLjXV1dd1aKpU+muU2JSktcRzfmPEmd8x4ez0xjx6e+iqImGS6hNUkU0rNAdpI1vqbTtJpUtGXYrWxmdTX6cGPA98OHWIzJmW5sVmzZv1h0qRJi6IoyuzaLklKQxzHneVy+TcZbzbPk2/fSrJmsHqpN6cClegIHWAL9sl4ex3lcvlXGW9TkvosjuO7Zs6cOT/jzU7OeHs9sSZ0gKKzWPXeqtABtmBvoCHLDcZx/PMstydJKbk6wDZ3DbDNSi0PHaDoLFa9l+cZ6QeR8enAmTNn/hn4Z5bblKS+iON4bltb260BNr13gG1WakHoAEVnseq9Xt8xkJEDMt5e3NXV9YOMtylJvVYul39M9pd1NJD95Ro9MS90gKKzWPVe3n/4jsp6g1EUXRPH8ZKstytJPVUul9eUy+UQvwzuToarY/TC7NABis5i1Xsvhg6wFUdnvcG2trZl5XL58qy3K0m98L+zZs0K8Qvy4QG22ROzQgcoOotV7y0j36cDdwNGZr3RtWvXfieO48VZb1eSKhXHcWd7e/vXA23+yEDbrcQy8n82JvcsVn2T52YfAcdlvdHnn39+Ublc/krW25WkSsVxfM1zzz0XYt7FIK/LPfAUyUSa6gOLVd/k/S64k0NsdMaMGd+P47gWZ+6VVHBxHK8G/iPQ5vcg37OuPxk6QC2wWPXNU6EDbMXryHg+q3Xa4zg+P8B2JWmLoij6TltbW6j1bV8XaLuVmhI6QC2wWPXNtNABtmI74JAQG25ra7urXC7/OsS2JWkzXly8ePFlAbd/WsBtV+Kx0AFqgcWqbx4PHaACbw614a6urvPjOM7zBf6S6ki5XP74ggULVgTa/Gjg0EDbrkQHMDV0iFpgseqbF4C5oUNsxRkE+j7PmjVrXldXl6cEJQUXx/GtbW1tIY+iB3strtDjwOrQIWpBnr/JRfFw6ABbMZaAt/fOnDnz+q6urutCbV+SyuXy/K6urg8EjvHOwNvfmj+HDlArLFZ9V4QfxqBP6CiKPhzH8YyQGSTVpziOu6IoOmvmzJnzA8bYCzgo4PYr8cfQAWqFxarv/hA6QAXeQcAlFNra2pZ1dHS8JY7jVaEySKo/cRyXgY+0trbeEzjKuYG3vzVlivFeVggWq76bAiwNHWIrtgHeHjLAs88+OzWO4w/Ecezkc5KqLo7jjjiO39Xa2vqjwFEGA+8KnGFr/g4sCh2iVlis+q4LCP3bUCU+GDpAW1vbdc7KLqna1k0C+ua2trZfhM4CvBsYFjrEVtwdOkAtsVil447QASpwEHBU6BAzZsy4pFwuXxM6h6TaFMfxMuC1ra2tvw2dheQ99oLQISpwV+gAtcRilY7fUYz1lS4MHQCI29ra3l8ul28LHURSbYnjeEG5XD6utbU1LxdivxnYLXSIrVgK/Cl0iFpisUrHSxRjKYA3AAeEDgF0AqeXy+XbQweRVBviOH6+vb39mBkzZuRl9vAI+GzoEBX4HcnkoEqJxSo9RTgCUwKuAvqHDtLW1rYWeEscx7eGziKp2OI4bm1vbz9q9uzZeVq/9U3AfqFDVOCW0AFqTRQ6QA3ZFfhn6BAVugz4XOgQ6zS2tLT8sFQqnRM6iKTiieN4Wnt7+0mzZ89+KXSWDTSQLA+zZ+ggW7EWGAksDx2kFnTf9O4Rq/Q8TTHWDgS4iPxMVtfZ1tZ2brlcvsSpGCT1RBzHf25vbz8mZ6UK4D3kv1QB3I+lKnUWq3TdEDpAhRqBq4EBgXN0i9va2r5ULpffEcfxytBhJOVfV1fX3cuWLTtx9uzZS0Jn2UgzUJRpZW4OHaAWWazS9UuKcXcgwB7ApaFDbGjGjBm/7OrqOjSO42dCZ5GUX11dXTfOmDHjjfPmzcvjL2KfBUaHDlGBduCm0CFqkddYpe8+4LjQISrURTK31V9CB9nQiBEjhowYMeL7JBPrSdJ6XV1dP5sxY8YHSF6/8mY3kmur+oUOUoHbgFNDh6glXmNVPT8JHaAHGkjuEhwYOsiGFi5cuPyZZ555T2dn5zviOF4YOo+kfCiXy9+cMWPG+8lnqYqAKylGqQLIw6z0Nclilb6bgSKVgV3J6fUAM2fOvKG9vX2vcrns4WqpjpXL5SlxHJ/Y1tZ2Ifm93OKDwLGhQ1RoOcWYIqiQPBVYHd8GPh46RA+USV4QHgycY7NaWlreGEXR5VEUjQ+dRVJm/hnH8edbW1tvIr+FCmA8MI1kwfsiuBp4b+gQtab7VKDFqjr2AJ6gWPu3FdgXWBU4x2aNHTt2YP/+/T9dKpUuiqIoV6cvJaUnjuMl5XL58zNmzPgRyUoNedZAMm3B0aGD9MBRwEOhQ9Qai1X13QWcGDpED11OARYMnTBhwriGhoZLgXdFUdQQOo+k9HR1dd3d0dFx9nPPPTc3dJYKfYZk0uWimE4x5tgqHItV9b2WZA2mIimT3NH4h9BBKjFhwoS91x29OiOKoqbQeST1XrlcfjCO48tmzJhxZ+gsPXAUydGqxtBBeuATwHdCh6hFFqvqi4Angd1DB+mhmcCrgBWhg1SqpaVlLHBWFEXviKJon9B5JFUmjuO5URTd1N7e/uNnn312aug8PbQ9MAXYMXSQHlgDjKVYN1gVhsUqGx8AfhQ6RC9cCXw4dIje2HnnnXdtbGx8XRRFJwHHeC2WlB9xHHfFcfwYcG+5XP7dzJkz/0xypLxomoB7gGNCB+mhnwGuy1olFqtsDCQ5ArRD6CA9FJNcH3Zv6CB91G/ixIkHRlF0JHBoFEUHRFE0LnQoqY68XC6X/x5F0cNdXV1/6ezs/Mtzzz23OHSoFFwOfDR0iB6KSc5G/CN0kFplscrOJ4Fvhg7RC7OBfYBloYOkacyYMSMGDBiwb6lU2jWO40mlUmlXYCdgTBRFw0Pnk4omjuNlURS9CLxQLpdnxHHcGsfxU6VSaWpbW9vzofNVwUeA74cO0Qt3AyeFDlHLLFbZGQzMAkaGDtILdwKnAB2hg2ShpaWl/8qVK4cMHDhwULlcHhjHsc8PaSNRFMVxHK8F1rS3ty+bO3dubqdoqYKTgVtJplgompNIypWqpLtYKRsXkxyGLeK4Cgu4JB0OrCT8a3JvRq7Wg61VcRxbrjI0BFhA+CdXb0cul7yRpIzsTXInXejX4t6O16a/S7Qxi1X2PkH4J1dfxsfS3yWSlHt7APMI/xrc2+HRqoxYrLLXH3iW8E+y3o4y8L60d4ok5dgewIuEf/3ty/CC9YxYrMJ4N+GfZH0ZncDpqe8VScqfV1HsI1UxcF/qe0WbZbEKo0SyAnroJ1tfRjtwRto7RpJy5HCKfU1VTHKW4YC0d4w2z2IVzgmEf8L1dXQC70l7x0hSDryB4t79t+H4edo7RltmsQrrJsI/6fo6uoDz094xkhTQR0jm7Qv9+trXsRrYOd1do62xWIW1M7CK8E++NMa3KeZkeZLUrYlkmZrQr6dpjf9Ide+oIhar8L5E+CdfWuM2krm6JKloRgG/J/zraFpjJsk6tcqYxSq8QcAMwj8J0xpPkUyiJ0lFcTTwAuFfP9Mcb0x1D6liFqt8eA3hn4RpjlXA+1PdQ5KUvgbgs9TG9VQbjlvT3EnqGYtVfvwv4Z+MaY+bgdFp7iRJSsnOwB8J/zqZ9lgCjE1tL6nHLFb5sR3FXkdwc2MRcHZ6u0mS+qQEfBhYSvjXx2qMc9LbVeoNi1W+vIPwT8pqjXvx2itJYe1JbR6l6h53A1Fqe0u9YrHKn18R/slZrdEBXEFydE6SsjIE+DrJihGhXwerNRYD49LaYeo9i1X+jKD4i31ubSwiuWC0OaV9Jkmb0gh8EHiJ8K971R6u35oTFqt8OplkfafQT9Rqj3nAJ3GuFUnpKgFvB54m/OtcFuNn6ew2pcFilV8/IPyTNavxPPAxYHAqe05SvWoEzgL+QfjXtazG03j0P1csVvk1APg74Z+0WY4FwBeBkX3ffZLqSDPJ+n61NNlyJWMF3hSUOxarfNsVWE74J2/WYzVwDXBQ33ehpBo2AfgGyYXboV+3Qowz+74LlTaLVf6dSfgnb8jxOHAByUX9kjSI5HTffdTHtaibG9/r645UdVisiuH7hH8Shx5rSJZpeDcwrG+7U1LBDALeDFxH7U7s2ZPxANDUpz2qqrFYFUMTyRMp9JM5L6MduAe4GDiYZL0vSbVlD5Kj1beSXEsU+nUnL+NpYHgf9quqrLtYOVNr/m0HPEqyvpVeaTHwCMnF/lNJTh+2AV0BM0mqTATsCOwL7A/sR/IL05iAmfJqIXAoyeubcqr7aJXFqhheBTyEt9ZWoh2YDcwBXiB5QVq67uPdK9lLykZEcuS9kWQW9GEkC7SPBSbiVCuVWAOcCDwYOoi2zGJVPK8FbsPz65JULzqBtwG3BM6hCnQXq1LgHKrcncCHQoeQJGUiJnnNvyVwDvWQxapYfgZcEjqEJKnqLgJ+GjqEes5TgcX0TZK19iRJtedzwGWhQ6hnvMaq2CLgu8D5oYNIklL1eeCroUOo5yxWxRcBVwIfDB1EkpQKS1WBefF68cXAeSTrZUmSiqtMMimqpaoGeMSqNlxMcj7e76ckFUsH8F6SZXtUYJ4KrD3nAj8gmYhPkpR/K4EzgNtDB1HfWaxq02uBXwLbhA4iSdqil4A3An8LHUTpsFjVrr2A3wLjQweRJG3SdOBk4NnAOZQiL16vXU8AhwB/Dh1EkvRv7gaOwFJVsyxWtWke8Grg+6GDSJKA5E7u/wJeDywJG0XV5KnA2ncW8CNgUOggklSnVgLvA34VOoiqx2us6surgF8Dk0IHkaQ6Mx04HXgydBBVl9dY1ZepwP7A/4YOIkl15GrgYCxVdcUjVvXnTJL5rpySQZKqYyXwUZJipTrhqcD6NpHk6NXhoYNIUo15BHgX0Bo6iLLlqcD6NgM4Gvg0sCZwFkmqBZ3ApcCRWKrqmkestBtwFXBo6CCSVFDTSe76eyR0EIXjESt1+yfJb1gXklwXIEmqTAfwFZKbgyxVAjxipVcaD1xOsn6VJGnzHgPOIbnrWvKIlTZpNnAK8Bbg+cBZJCmPlgEfI1k6zFKlf+MRK21OM/AZ4JPAgMBZJCkPfgV8AngxdBDlj9MtqFI7A18nmTlYkurR34FPAfcGzqEc81SgKvUscAZwLPBo0CSSlK3ngPcAB2CpUoU8YqWeiEiuv/oyyTQNklSLnic5Uv8TnOtPFfJUoPqigWRm4f8guZNQkmrBbOBrJHP7rQ2cRQVjsVIamkgK1qeByYGzSFJvTQG+TXJxenvgLCooi5XS1EByivAzwL5ho0hSRcrAb0kK1e/DRlEtsFipGiLgeOB84GSSwiVJeTIfuBr4MdAWNopqicVK1bYL8GGSmYmHBc4iqb7FwH0kZeoWPN2nKrBYKSsDgDeRXIt1ItAYNI2ketIK/By4DpgROItqnMVKIewAvJNkXqyD8OdPUvpmAjcCvyGZey8OG0f1wmKl0MaSrEv4OuDVwOCwcSQVVCfwCHAHycXo08LGUb2yWClP+gEHA0cDh5EczRoVNJGkvFoD/A34M/AQ8AeShZGloCxWyrvtgb2AFpL1CkcBw0lK2IHrPi+pNq0imQJhFfAyMIfkGql/AM+QHKWScsVipSK7CTgtdAhJVfM0LpulgnERZkmSpJR567uUvQ+RzKlTS/4CbBc6RB8cDCwOHSJF46i9nzGpECxWUvbmUnszPneFDtBHs0iu5akVTjEgBeKpQEmSpJRYrCRJklJisZIkSUqJxUqSJCklFitJkqSUWKwkSZJSYrGSJElKicVKkiQpJRYrSZKklFisJEmSUmKxkiRJSonFSpIkKSUWK0mSpJRYrCRJklJisZIkSUqJxUqSJCklFitJkqSUWKwkSZJSYrGSJElKicVKkiQpJRYrSZKklFisJEmSUmKxkiRJSonFSpIkKSUWK0mSpJRYrCRJklJisZIkSUqJxUqSJCklFitJkqSUWKwkSZJSYrGSJElKicVKkiQpJRYrSZKklFisJEmSUmKxkiRJSonFSpIkKSUWK0mSpJRYrCRJklJisZIkSUqJxUqSJCklFitJkqSUWKwkSZJSYrGSJElKicVKkiQpJRYrSZKklFisJEmSUmKxkiRJSonFSpIkKSUWK0mSpJRYrCRJklJisZIkSUqJxUpF1BE6gKSq8jmuwrJYqYhWhQ6gf1MOHaCPip6/1qwMHUDqLYuVishilT/toQP0UdHz1xqf4yosi5WK6MXQAfooDh2gCpaGDtAHXdTeEZKi/4zNDR1A6i2LlYro+dAB+qjW3sQBFoQO0AcvU/wisrHloQP00bOhA0i9ZbFSEbWGDtBHRX/T25TnQgfogzmhA1TBUopdFmeEDiD1lsVKRTSV5PRNURW5hGzOU6ED9ME/QweognaK/XP2t9ABpN6yWKmIVgLTQ4fopSXAvNAhqmBK6AB98HjoAFXyROgAvbQCeDJ0CKm3LFYqqrtDB+ilR0MHqJJHKO6ddQ+FDlAlRX1cD1DsI9KqcxYrFdUdoQP00gOhA1TJCuDB0CF6YQHwWOgQVXJX6AC9dHPoAJJUjxpIriGJCzZ2q8bOyIlzCb9/ezp+UJU9kQ8R8Azh93FPxmpgRDV2hlRtcRwTx7FHrFRYXcDPQofoob9RmxdKd/slsCx0iB76SegAVRQDV4UO0UM3AAtDh5CkerUdydQFoX/LrnS8szq7IVe+Qfj9XOm4t0r7IE9GUJznSBnYtyp7QcpA9xErqei+Qvg3hErG0ySnL2vdSJI7H0Pv70rexA+pzi7Inf8i/P6uZFxXrR0gZcFipVoxGJhJ+DeFrY3XVmsH5ND5hN/fWxu1fApwY9uSTPERep9vaawAdq7Ow5eyYbFSLTkO6CT8m8PmxrXVe+i5VALuI/x+39yYCQyt2qPPpzMJv9+3ND5cvYcuZcNipVpzMeHfHDY1ngaGVPFx59VokjUdQ+//jccKYL8qPu48u4Hw+39T42aSOxilQrNYqdZEwA8J/yax4ZgHTKrmg865vYHFhP8+dI8u4NSqPuJ8G0IyG3vo78OGYwrJ6Xyp8CxWqkUl4MeEf7OIgfnU75GRDR1FMgVD6O9HJ/CuKj/WIhhHssBx6O9HTLLm58jqPlwpOxYr1aoI+CLJXV+h3jBmArtW+4EWyAEkRTNkqfpk1R9lcYwjWTQ7ZKl6ECcCVY2xWKnWvYVkosGs3zBuA4Zn8PiKZhIwjey/HyuwVG3KUJKf1RCl6gdAv+o/RClbFivVgx2BW8nmzeJl4N3ZPKzCGkQygWgH2XxPpgN7ZvLIiut9wCKy+X7MAk7K5mFJ2bNYqZ6cCDxKdd4slgP/CQzL7NEU317ATVTvdO1S4KvU35QKvTUC+Cawkur90nERMCCrBySFYLFSPTqeZD271fT9zeIfJKeYts3yAdSYycC3SG9ahjaSN3BPxfbOcJL9l8adg2XgYeADJEcqpZrXXaz+P1BaktgREoMRAAAAAElFTkSuQmCC">
  <meta name="viewport" content="width=device-width, initial-scale=1">
  <link rel="stylesheet" href="https://cdnjs.cloudflare.com/ajax/libs/font-awesome/4.7.0/css/font-awesome.min.css">
  <style type="text/css">
    body{
      margin:0;
      padding: 0;
      
      color:#1c1c1c;
      font-family: roboto;
      position: relative;
      text-align:center;
    }

    p{margin:0;padding:0;}

    .clr{
      clear:both;
    }
    #bg_mob{
      background-image: linear-gradient(#28313B, #485461);
      //background-image:url("data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAZAAAAMTCAYAAACPBEGTAAAgAElEQVR4nOy9e8w1V1k3vGY/93O30HIoVStYRapAPfBC0ICveIgmimliROMhEdQXY1CJJgYTD38oIInRGDVRPyLfH+LpTTioFKEFDwkCpf1EasW2UBFQBLSV2pa2T8tzuufLNfe+5r7mt69rrTWzZ/Yc9vVr93PvPYc1a9asuX7rOq1VlGUZHJv41Kc+9b9542q1Osffi6Kovh8dHR3iSUVRBNmeZVkewv5zuA33FQWdF0LqudC1ZHllEUIBp3AZZVmevnjx4uEll1xy/1Oe8pRb/XE7hsKDDz542ZkzZ66h98Pq6yGk+/fFixcvk7/5vWAcHBycwTLw/bO2BXinNTz66KNXnzp16szp06fPXHrppfdccskl9zzucY87M2THOXPmzOFll10WrdfUsFcE8sADD1x17733ft0jjzzyxTfccMPvfu5znwv3339/9XnggQfoAYZz586FCxcuVH+5862FdVUG/9U6Km+3Oq08hvdr5dG2o6Mj9Xw8D8vmsk6dOlVvp/s5f/58uOyyy8KXfMmXhKc+9anhec973l01+RzXh154uu7p1Wp1nv52a+U8nDp16rxsK7qeJOXUCz514ACj7f2QgJT9j/8yzp8/f1nsfBowyN/YP0gwatt528WLF6PP//LLL/84f3/44Yevueeee6766Ec/Gj7ykY+E//qv/wqXXnpp9P74HbD6/+Ghzj18HPVnPC+IdwTfD7w/PA6vL9/71WpVvU/0l7c96UlPCo9//OPDk5/85PBlX/Zl4RnPeMYffumXfun/vfLKK2/JIRoi2sc//vGDEtIusFgC+eQnP/m/P/OZz3zTRz/60Zfdcccd13zoQx8KH//4x8N///d/V0Tx2c9+tjqOOsPBwUHV4R/zmMdUf0+fPl0JXYZGIHJfDJYA0Agip5zYNhAAdYene6F7pmteccUV4fM+7/PC3XffXddB1gU0qI168L0wQeFLqH3X6szn07W7XN9CbH/q3BjajG7DMWFs3DOea+3DsmP9x+p/1L58DNWFvss60W+rb2rl4zEPPvhg9ZvelUsuuaR6hwjU1+jcyy+/PHp/qf6P9cN20fpfG6T6AREYvUPhmIx5kFPXi+QHfaf7pfsn2UEf+k71+cEf/MHwlKc8JVx77bW/9/SnP/3/ueqqq+7Krd6cyGVRBHLrrbf+/J0fuvOX7v6vuy97wxveUBPFQw89VD1oIgcahdPfK6+8siYG7pR0DP+lzhAM8sAXUYJfVu7gwRgl0TU0IcHfuRwG/g6Jl4fKp5eaXgQ699FHH6WRYnUOdXJ5D1YdsV54n7mwBKjcTvdmCcgUkXQhhm3IJAfUPl2FWwAtVas3t79F2tZgw/obYACSI2BJCyBNnetDfZ76HNctRoIsnBHcz6l8S9sP6/6NsN7FIPor/7Y0INluXGf+yPLpPnkbWTLo/aK24GM+9alPhSc+8Ynhi77oiyoN5Su+4ivCV37lV5659tprf+vqq69+61JMybMkkIceeugyVhNvueWWX7v55pt//n3vex8RSPiP//iP6hh6cNSh+UMPnP5KwqDRE3VU7qySRKQKji8lE0AMKQGbGkWnkHpu1JHpJWUSoTL5hefRqPxLbcNlsvDD+qS2Yd0ts0BQhBW+uPJlHer62rVjpkXrOlbdQkIYWyYU+dsSgCzAsE68jUfN1v2yxpCj5WntJAUoE4gwR9bld4UkGK2N5ABtCJBs4Hvjv1Qnbn8iDDqG3xV+t1gu0AD0kUceqUzjpK2xCZm0fyKWH/3RHyXt5A+f+9znvuIJT3jC/YPezICYHYHcf//9Vz344IPP/LM/+7N3v//97w/vfe97K5srgbSKz//8zw+Pe9zjKq2DOz09ZCYKIgbq3DQa5xdJkgp3XBqlMzQthDpLDChEQqYAZEiBroH3WQKP7LPUBmfPnm2QiGYukppYUAS4Bn6pELmmHhwB4vVzSTR3hJ977DZag0RKg4qN9vsYQKQGMNzPrXrk9D/+8CCNhak09VjI7d8SqNHkoksba++qLIfulUmDwaRKbUtEwgNXNiGTzGFNhfyuZOL6+q//+vDN3/zN5JN8zTOf+czfnhuZzIpA3vnOd97w+te//robb7yxehjE6E94whMqYckmJ3p4PFJg8mC1WmogJFClKSCA4GInXTA6bpsREAp7+svEFSMQ61xUp7Vy5IgQ/4aMF6jNC2bVIQZp49YIemik6mo9X65zWx9WW2xLEFi/XGJnpPr3thp4qv3KUu+vuJ2hmYC3AcmQ2PW5DzBZyP4cgGCt9iPzOmkn9J3k2HOf+9zwvd/7vfdfd911/+vKK6/81FY3sCOMRiAPP/zw4eWXX56MTLnnnnuufec73/mBN7/5zZfdfPPNlUpIDjrSNKQJikc/TCDSDqvZ+1nFlgJMnqOp4G0FsGxb2ZnKtR/CAhIElpN7/RRio+3c8jUzSUgIiNRosC0ZacgRUBo0c42FberZlqBDy/63LVLlp9o3JcCtdm7T9nh87Fw8LkfDtuory2ICwTJZw5I+FzlQYg2GzqUPaSZUFg2Gycz10pe+9P5nP/vZv/CsZz3r/002xoiYrAbyiU984ptuuOGGd7/xjW8Md9xxR7WNIojIfkiaBzI8ax04Qpcj8SBGvkQ+QSEQ/p4agVkagOwgQdEc5DExAYROZXwxtvGxYH00aHZ8VOG3ub4svwtBptD2fI3wY2g7wkXhlvN8UvXtihzi25ZAUlFSlhOdsW3/Ghqy/vwu8eCVB4gyeisIWURtw6Zl9s3ScWRVIa2EyIQc81/91V8dvvVbvzW88IUvfM3zn//8X869pc9+9rNX7MoUNjkCufPOO//Pbbfd9luvfe1rr7jnnnuqBiX17uqrr640D2p4alx+CaS9VXZWOobNVmy6CgqByIcaFMFvgQW8NVJEJ6UmnGKjzFLxD7QRGjn1t64dOpogJNHkjEAtdT93FBrD0AKo7bPA47tqSFgH67hcgrPaetv2SYUxb2sCTPW/oTU0NnHL65AmwQNZ6Q+R7wTLGyKYch20w1FnJJPoeCIQ8pnce++9lRx7xjOeEb7ne74nfN/3fd+3Pe1pT/tbWY8HHnjgiic+8YkVWcjgol1hMgRy3333Xf3e9773+re97W1fc8stt1TbKEmHEnaogYlIyPlEgp4am/M4tJE0PSB6COzY44cWQHhLbUP6R1IdMEYcvF06CbW/bMLSVPByHdURQFvJ0Vxyn2eO2h9rA9SQsBwrjBXbR96zZjawoI3o8WXOaYOYKWtMpLTDsU1c22po8v3Q+iKHuXdFqv+lNKAUqH5IkuwTkQPaALKGieSxj31sHQHJScvkxy3WEZ4k+8jR/slPfrLKXaP2+tqv/drw/d///fe88IUv/Nqp+EgmQSDvfve7X/emN73pZR/84AcrwU/ClSIUWA0kFuZQU2pcCo/jDiAfFrN9KULvNNBDIk1GjgrQyZ5jW8V8EAy1RC1F/kVSszo6HoMmMi1BTIt/x2NzScMyu8TOj5mk0BSGx8ZIAYH1kWWjJqm1o3a+1Qaxa1l/Y0iZSHNNXFof6kODk4i1VVf5EdNAinXIeew+aLSeItGQaKfY9bW+YPUB3idlDw9g5Psqv3OuGWkq/F7KhEzy9ZI/hKwupI1QegINmr/wC78wfPmXf3n4qZ/6qdc873nPyzZrDYVRCYTmm7r++utvfsc73hFoGgRqQEq6oek2PvOZz1QNzgRCxMINTZ2HWJsJg6fqwIcoTVw4HQFHWUgzl9RWcASrdUxLKGrAEbaM8tJAbaG9ZLERpqwHZyJjvoeVlczAqDQLcoSn3b8WxiqPxfu3BH8byOtIH5d2fQ0x4YP14RF0DlngPQZlhG5d24KmdcfO1/oqauUSbUyYMXKxyFWGv2p14gGi1b+0+rUZgMggFm1gJANxYm1gaRrUv4u1KVumCsj7wmRQaWon8gjrfsYDafKRkFykyK2rrroqXHfddeEHfuAHvvmpT33qe6IVHRCjEcjHPvax61772tdSWG4lrL/hG76BMjWrh/I///M/tUbBDU0aA2eUkwmLftN+mRzHoHOIdILo6PQgSKhw5BY/LEkskmA0yM4sNRxthKZFfpXg9JfHBxBYUlNITTnC0KJArGtw22Id5fla+VLz0UZ3eD0NJZjo5LGp82ICQgqanCghS8DknC+j9CwNMqZVpkwosdF1Tv9LJWJq5crfsedg1R8JzBqYsDXBIgcN2Nc48snSEGKJjJp2HjLeLyQ4OVCV5EHl0n4pc/ge2dFO+WjchnwMv7Mc1iv9uzzFEllfSBMhsxbJvRe84AXhJS95yR9+y7d8y0ujDTgQOhNIzsyR1jF//ud//uGf+7mfu5YagDQOsu0R4/K0I7SdOgAJGSIK6Zzi37SfCYS3yVhs2kaNTiogJRbyPDXcaVjDwI5ehjIUoTj5tW6e2KhNE2I4As9RoeVLop2vXV/bliOgUmg7Ag5hc/SJbdPGrBILY2ZNRdMsqv10maPN60utVL7UUgDIdo/dn9a+ON1MTGBLIkaBxiaOYLRjyPTxpFCAv0+SUsrEmtKgkRg0ksL7Sw1gsPyYFpYbZqw9L6uesvzU/dN+aVLnZGbqd2y24rJpO5uvmGTIR8JWFd7P/ZO1lfvuu6+y3FDZP/3TPx1+8id/svGQduFUH0wDsSYE+4Vf+IXyj//4j6tYZ0qcIQIhYU/MysxNqhr7PeSLSt+JXOh47gD0mz5s4uLsT1Lx6C8/GB7x8EtCZWAnQ+GhCe5gvFAWuViEkerg1shYXiNWr10TSO5oUgqr2DENQgCytEKc8frYPlJYyzwgKTilxqrdIwOdvDTwoP9lna0+goJK014xMQ3Rx/NFAkEtOVdj0fZ1kSvyuacGG5aGpbWvda0Az0D2rdhg0dKupIZO8qUUM1twZBZbOSgVQcok3k8DXtpHA+libYrlmYm5fB5cczL0XXfdVflMvvEbvzG8/OUvf8VznvOc39buOTf3rg22IpA2FSJH+Wte8xqaGbfSCH7oh36o0jqILOjmuTHJvsdJNXKeGSIUHnUx0VAj85QklB9CH9I6CkgELIWT/dz5c6E8aobIpuy5mppsaQYMTCDC710IRKujhW3CJHOEgNZOqTKl4McgB2xHfvbyxY6RFtaJXzbZjtLsoPmYjiIz1FrXyWkfbZ81Uka7eNcBSAr8LJBA+G8XH0RQ+o7VNzSNBLWtWBkxbSZWL1l/7OPaNayyCyPYhsEmtlLxy4Z1XyRykLOAy9D/cu3H5OmXmGQKMdU9J1GTk/1f/uVfwj//8z9Xg/Jf/MVffOu3f/u3vwjbgPJDaJmAPtcc6U0DoTmqrrjiinu0fe95z3te9yM/8iMv+/d///fw4he/mOZ9qRqQyYJ9EkQkRAjUYPSA2d7H7Ezn0DZet+MJVzwxXHnFk+rEQp7MrFzbEYMYdeLoiuOwgzESRKReaO34yN5wdJQWuN3LT8fJt9Uw2pQflPrntLU8XwpS7Vg0+2D0WRAmJTmi5w9Plod1LIXJIShCLNV22j5NMMp2kPvbkNQ24PbAoAlJHBpShBAbfLTtf7FrxYI0YvWXZYREv7TMbkFogFb/w9m42cTOpnga/LKPhAbUNJgmsxXfG8s7GZ0liYWOoQEzX49k4Cc+8YlA8wOSHP31X//18LKXvWzYWO6+CCRma3vjG9/4yZ/92Z+9mkjiu7/7uyuTFX3/2Mc+Vr/IYT27JREAv9g8TTRPFUC/iTxYE/niL/7ihoZCpMKNSw1Ox2ovJ0da4WgTO1DM/KBpFIgcDWOb863nJu8nNmJvQyCx460XnNtYvuyyTm2jkHB22dT1+Vj5UsuRtdRQMdway9eeUWy0atUL+6JFwkUPPqwU2ASnmbBChg9CE+D4u03/w21oorK0k1j/S5EQnq9917ShAD5UrQ24f8mMfLon9mtI2UXmLjqOiISmaCIHehBaDJu9+B0gGUlkQ4Ntug7PA0jbaGLZd73rXdX2X/mVXznzwz/8w5dzvYZY8XDQKKzf+Z3fKX/7t3+7miX3u77ru6rwXLpp+lBj8iJH5donwZoIaR1MJNTARAb0OVpnbBJB0F/eHtbTJ3O0Fn3YSVrfKExRIlccZMhOaXUcRErANJ3yMdDx+QLeeoFxfw5SJoKgvPzl2lmNy+gGeIGDGO2WwnYsBXjq+rKcINocNQ6Gth0HCaiB4H6L4HPfF/TTaG2E15UCvQ8neQwxAinFgk0WtFG/RG4/tsrA56f1vxg5FEquDx4TRD3lYCdGcJbGg8fybLwFhOvyIIb7HwcCHYnJX+m8pz/96bWGQtvZ10vbSNaRr+TTn/509Z2SDjkAiciHjidNhCw8L3rRi8Kv/uqvDqaJDEYgf/D6Pyh/6zd/q7rRl7zkJXX2OLEsNQSpWdRwJEh4BUDWGoq184hinimklxqZVDRiWI7Eosbh8Dc2U0m1Ugow7a821UisLXI1D3l8rIwU2mgIGmKj6jYmBOuaF8sjlTyIVFahaDihq+dDBHl0ogHkJoLJ62pmgwCmKgaaFPg7j+KoPyIhaaNaFBxW/WJtpZ1vmXp2pYFIE5a8JyvE1RpsWVpX29E/XieHvGNlp64Z84FYg0Yk+th1eLolvhZqItwPmSToL1lhSK7R55nPfGZFDjzTOGsr1G/pNw2+OVdEZrSzY53k7pvf/ObqHFp75Md//Me/os2qiLnYmkA038db3/rWD7zoRS/6Gqo4zXXPUxez5kG2O+4gPKUxh9hyNBXNA8NJOEfrzE6ZnUrHBfEwmTSYsTnTnMEvxvGLQzbG06bgiAl6HH1of4PxMklsO5lcSsOwwoAtsOCPCVGtHRB8n3KqEql5MNljIh4KIiuPBp3jFrFbI1ouB01YsXvS6pkTBaSVEaCfYZ9LjZxT7Z8LzgPqqoGkouja9r+YaSpGOJpWYJ2T009Qu9FIBNtMuz7JJ6yLPI9N90wMPDUKh/rSioZEFGS9oYhVIgQmIh78MAlRX2bz/5M+78rw8IMPVXKVFtUjx/ptt90WfuzHfiy86lWv6l0T2YpANN/H61//+rM/8RM/cfjqV7+6dvKU60QYYmXSPFi9I9KgbdQQpJlQ49IEiqR1sMkqJOydEpogsohAU5FzzpPHWNe3RlDro2pTVdvyu0BrO23Ua42q6/OBYOQLJrUd7b4tUo1dn/uIJAx5nNRGUPsIRna9HF1riZSybnRtuegSCggtiknz9QQQHLItYmaTLv2vDWIaqgZLA8H6prbHzEN4f5pgts5NaTW4DwlAG0TErh/TfkNG/9POkedyagNrHWSmomVxSU7S4LpYT8jI5XFUIclTlrfUh2lwfvfdd1c+Z5qQ8dWvfnWvJLLVupNIHn/0R3/08C//8i8fEttRHgbdECW7cFo/3RDdGDcK/eVQNnaScwivNEG0GdXJ7dooAV9kDdaoo7oG2f0Vn4ZVNvtATvYPHhgRhdWOGhrtVq5zHWBEJQnqqLrXZvvjCLvNKDLIly+UYVWe7NOiX6woLHkcIyWgcwRsSnDFjg/QjmOgjVCPET4+O+1dtK4TazsckGltFRtcbtP/rPvp2v8CWBVSFgaaRJbM9hxcRANrIgPyI9NcWDzFE31YW+SAI5KpvG4SfUiLocz1v/iLv6AlMcqf+Zmf6a3Dbbdsl8Bf/uVf3vwbv/Ebl33d131dFYtMxEGNR5WndTyoIYg5iVmJRcmfwROKUWOReYsSYuhGqeEwegZHdQytY8VGNPJ3rhbQ6LTGKaYgKZv7tfKnBiTfWPs01HO419i5qedViASrEI61H3nckZjjTPN3hIiZRduOQgJ9aG36n3ZMl/43JFZiEtECJhVNCbdUn2BYwj5FmFb/Q0KwBm1tSN26JyQuPK5t/7O+a/vpfJ4rbCWW4yZSoFQICtel30QOJD85eZqDizjbnc34JH9ptg8q6zd/8zfD6173ut463qlXvepVWxfy9re//d0vf/nLv+Gaa66hOesbORgyN6NYh7exw+gLvuALKu2D1Cv60A3Sb7LfaU4uzTSCWgbuj3XanI6M2kvM7GHVUatbzvX7QuzaaIaR94P7rBGzZqaQ+1gz0eqglc3mHTk7cqWBGOYiK2cDfSXYn/DZxkaiWF9sH+sZW/eZgvU8doU2wlcT3vgbn+8Q/c+qj3Yvcq4563itbtjXc/tfAcmwkgDR2iKJiI/hubCIRD7+8Y9XcpQirsg/Qu8J+1GKtaWHiIW1F3K4U3gw+UTIt0Jhvpdffvmrnvvc577afKiZ2FoDueuuu178yle+8pvoRr7zO7+zzionJqQbYh8H3TxFDZB2QdvpL90cMSp9qKFoGy+ooj1kS6UOiY6bOjc20mjzwmsjn8qEpYycdgnrmnKUZY2uNWF6BKYsbCts61WwBcxRaM5FJYVLY1QWNkeEOFJOjfy0c7BOfH3se5Ygsu4rhi7Pf5fkEUOsHlobYf/SNIq2/U+eHzL6n0VweH3sf9qAo23/Y6B2YpmzUJvhpGpe34isNaRpUJguT2EiNQ6Wnewm4OW+KT+Eynr+859f/f6lX/ql8M53vvOGjYq2xFYaCDnRX/ziF3+AbuKlL31pVUFO+uNcDCIN+stzwxwenq5tdqx5sDpGznOKZaY572VsNELrMDkvmEYk1ggo9VurkzZCYn8JEtoYSGlkVpsFbPPyRLM4dnro5/B3qT1sCAr8uS6PNZAg6q2N9iXZoLCXo8NakzHyC/DZWMfGjk+1YRutYtd9RKtb13Nzjtum/6VMV9Y2rf9bpqsAzxfPy+l/WI/CiE7DkOqwjmLkBEMiB/ZtkJwkmUoyl0N+OVqLl7kg8JpJVC6ZsKgssuzQIJ2Cmz70oQ/RYlVPf8ELXvAPV1xxxb9mPQwFWxHIq1/96nMf+MAHwrd927dVmeHMknRTHIFFREDbWevgRMEPf/jDdagbL1PLJixL3cMHaZmVLHNWMF76tuYBbZSFo9jBMAL3VAmDsK1q/7VmoKHhsBbnhJokjGiZ9WY5MsQ5rdQ6Ki8jmgkKYVrAwQmSm5ZHpCFnQIB9rk1/HQqyfbVPSAjkHOQMzHLLiW3PrWeK7JE8NCKxoPW/IzHbhdb/pOkLp9vh/LZCTKh4JGYjJ02E8+noL5EIaxulWNSKc+tW6xme6Rgmm9tvv53k7otf+MIXdjZldQ7jfcMb3vDJ3//937+abGvf8R3fUc+gS8TBORsXLpyv8i3CmlGJPdlZTks10k3QjXPDEMEQ2/I8MQEejAZUiVMPWP5WjmpIaItYLHW7DYnktHvXZ2PVr8u1cuvQZ115O4cOVxpM0EeMuYjlLaTKTOXctC1v2+O7XKPt+V3rtI0mk1N+35Da6rb16UKOWAYTCwl+nkSxWPtAOPKKUyB4Snda+pa0DJomisJ9SY7SIJ7dBZSQTdfhKeLpQ4FM//iP/1jJ41e84hWUJ1JX/uEzDx9eflneJLlRHwjNtqttv/3221/2e7/3e1cTCz7nOc+pboqzIHma9MNLyCz1uNqUdfXVV1c3ctNNN1WVppuhRmBTFREHaSQ8uy6OiqR6qI1qUNVkducFXI7EpIpydNy0wW4SwJFYQyJmq7XqZH2GQNcXIYZdm1IYdF0mDUvLyYGM5GqLk76nP88xMeT1B9Wgt8AQ99zWpCvRd32kVsJrpnPyIMtJnu4prKeM5+nfaUBOvmSSobzYHh3PGgidxwFMJI/puGc961nVvt/93d9t+ENyySOkCESbqv3ee++95i1vecvrSNMgXwXdAK8KyJpH5Qh/5NH6HNIyaN6Wf/3Xf60ahh09mhkBoY0QynJTzcYyLFsnmio0gaAJYk27iHW+LlqAY6qYhgN76hibVOcI2WZagAebtjAwhP0jPM0T5YdQtBX5NsiCQxGuRB6cKlGuZwTmKYRYE3nKU55SXeMd73jHdbTEeNsmbB2F9Y53vOMDf/3Xf11VmMLCiNU4+7FYTyLGk36RU5wTCm+99dbKXkfHP/xIc+LelLDdGPEVm8SSIhnp3EpNXaH5SXB/UMhJOwa3OYk0se9Cx/vDMtBHP7aiB7XcHCn3iEDIr0F1+M///M8qzJdn8iB5yzMvsBbDspqsPSTDySn/N3/zNzR31s1t69yKQG655ZZfe8973nMFqUNkkiLtg7PHOZSsFOv+EvNRRUm1okxKni2XE85ijSKFLZJDEQkLxbKq/UXTKaqRwzYvchu7774LTIdjaRjKlIXzxzF4zj/2hxTr2XqJCMi3QZGt//RP/1QdTeRSEUco6/WUivU0KDz/FpEPyeUbbrgh/NVf/dX1beraikBuuOGGnyczFGWaEzlQheQ6HDy/EKtMZOKiNXuJQMjZHtazVPL89bJRcpy4+B2jqDSNoNoXmhqMZhPfxvnXxpnWxk/hZLMduvo+cpGKDpoqXOvpD0M9a0keuC2sl0Pg58iRrkQK5EwnUiCZS7N6kLytVjU8PJ43i5MNOSKLnfXkgKdz3vjGN35Xm3pmEwg5WchrTyDzFVWYY42JDWWEAFWMmI+YkDSP6kKroj5OTgKGDvKQGUIXC8GUv+VEfDGNJ1Z+X0Ciy8EUhJET2fQwJAn48x4HVpKh5hshOcqDdh7AczATmaWIFIgQKIGQEwrDehZgXg2Wg5hIjpMvhAb2t9xyS/jTP/3T+3IbIItA7rjjjpe95S1vuY4u9LSnPa02W8n5Wug7L8HI0VQUrstC87OffbBiTe6cMsFLg/RZoLahmbbQHCXzSLSoLnksmssQqX0xU9gQkVGO/uDPxjFFrMTKqTI6i3+z7A1iviz2PxMxUIQsyWmKziJfNE9oyw74sNZcOD+EtpPFiM75kz/5kys+8pGPfF9Os2QRyC233PK697znPRWr0XxXFHd8JNb35VkgiQU5UZDIgzMgefEnujl26KBdD4V0U6Pgv5uJQ5rpSYvMwmQ01AbaOM1T18LfmmaFGFqQbTuqnOOoNDUpoMMxNbBc1MyvUkPhY3gxKlPbkIQAACAASURBVJ65gT681C35qCki69/+7d/qpG1eb4mX0uA1l2g7RdZSlCxpITfddNObst6x1AF33333s/7gD/6gusizn/3selEnXiuBKsKEQKDEFlKbOCGQKsmLp7B5ixZ0kg1imZ9Otm86zVNagdR22KnP15RJivyReR4n5GLnc2BdEbIjyI9sO1lfNxvMD669OPoGzosVjHmz5EqunDrB20i+kSZBspmc6jTgJ981EQuZqWggT32XvpN8pmM5f48c6kQir3zlKykyK0kiSQK58cYb/5mI4Ku+6qvqxBQp7DiemCMBaD+RBFWMHTbMcmW9nGMzjV/L1UgJadyO52JEV1CISh4vfSUn56ezn7sI/pTW0hVOQtNBzrNwAmqPJfdxSRiobQQlKMTSUuS5cmJbSqPgiFl2OZwM6ss6UZECnsiKdOuttybNWFECue+++65+61vfWjEZeenponIUzfY0TggkhiNzFTt02KzF2ZN8HncC2QDo8wgg5BtkAbPBBkUzsYS01DC0GVdRy+iqHbhwyMOU22kfzX59w9sgDekXbqyBAySCi1hJ4EzA/JuniyK5yxMwyunfj8oTcuJZQygJkd7Lv/3bv6XpTn4+dgNRAnnb2952FyWlPPWpT60uxs6XsDYLSZKgCvF8WFw56aBGM1IAE5amfVhmKi0PRCMOK7RXEhNqHqjBIKlp9dHgL45jqph731zyuyU1CCuUVxKKRSpk8eGBPU9jQrKZrEk8M3o1g8jZc40Z1Mv1RI5EIpRL8r73ve/XovW1dtA8WDfeeONlFI5LKg35Nnjxdo4jJnNVWPs2OISMk1Xw5phAivWCJxKa2SkYznJNmGtEo23XOh5GdDWjvvQIL82ZPnc44Q0Db1dHLpAw0Pch92NUVlCy13lGXjn5Islo0kI4rJdlNss9dklQqgaZsW7+/26mfJJrrVswCeSmm256C+VxEHlwwTwJl0yJpw8vAM83wNO6y7V6pelK3vzJC9YtHBYjsSw/ijwey7S1i81ck5hGg1iaGcuFoWMqWFpfRLO+9VeDFm2IA2Ne8pZdDbyQWxCDYpZxJN95jZHbP3g7ZaebU5yoBPLAAw9c8ba3ve06KpC8+EQIVEmeKZe9+JwQSIwmzVscXibXW+aUezmlSPNmmzkfBeRuxPwdITT9GEEhB/SjaOuN2JFdzRXLcolhnwTuFO916Ex0Rx584NEOMgeEoUViSU1kBevZc46H9KvwoJ4G85+9/4F6zXTp02ZnOsl00kIoj+Qv//KtV9x///1XaTehEsgjjzxyzd///d/XU66zikNmrHpulaOjer55sqvxvCrlerp0zABnbYTVKoZGAvJ3MDSIWBgvHmsdh2Yrm0jshXGWpGX4i74/8Gc9PfDEh0ExR+F3bZ4seY4M62UfB0fEkiym0F72eRytF/6TfmuS9TQRLk1Vdeut/0hLcXyT1mAqgbz97W//ABXA3nsqkP5SdiMVyARCGgkxFF2YkgZpG68+yFO8c8W4HEzoY58IfZh4OIeDb5iP4XNZm0HCYZTr1H55njyfMzf5Nzcim9Tkanbyg4mPMfKQJCpHB0Mnt40pGFwoOSzMoW9MoY7aLLzafFgoU6RznT6U9E2yl6eXImWAV3sNYiDP8pl9IWHdDmS+oqita6+9tkpEvP7669WckANtI2kfZLoiISuFPmsiYT0pF30o25FYjr37PN+8hOYA0kLR6rIvXqgjrfimZPIdJuIhCmMFw1roF00TllYPaUbTwoljnU030XUHmt+mjKHq2qVMfPkcjrlAi7RiYJ/WTFqlMsGslF1cPpuuMCJWXoNkPGWnq+8Ybrj11lt//h/+4R8qbYOdLkwgUpOg76SBENHQcWzGIgJh34h1w9pLXY/+q/Xneoq/X//ZED5lvkBCgeij7P7guTLd4f2wf0yhP2qDHmsQhOQiv7ObgGX3kViNlaOyeE4tvm+5ZogMfKI5sv7u7/4ufPjDH37xRh1ww2233fZrNPkWkwCvNEiFkYbBk3jxxdi3IX0gPDdL7KY1raRivrDdiLHhNwGisDoIJyaq+wZYrnbOL/9YdZ9im3k+haNvxEJy0WEehA/EMo2TCyCs5TWTCvtByvUqhTJAiGU9k0ixXp6DzFnXX3/9n2L5mgZSJ5Nw8iAnB0pmOlqvdkWEwvNdcco8mpi05JgQmgmFG4TTc9+OOtsjF4vljuSUP6VR9tLJzeGYOyySQGgEg5Mwsh84iBnK+XhJLDgPoCyLk8RJtr/lLW/ZqEeDQO66664XU/Zh5cdYyxF2tEgC4e/klGGthBNVSpgsEFUsbbIwlUE7yF3L3mdFUOXAyj3RtuUe63A4HBqOYDVChjU3lhXGq8lCNMVzlBbL9QD+Y95GMv7JT34yTWsSPvjBD/5Uo17yx+233/4rFFVFyYMHq1N1BNSRWEeX/vKcWJwuz5Dzy+cyqDVRWJ+IkclJixqbW2SdtyGLJZuChrqGk7FjH2CRh/ytyVYpS1n7wLm1JLHwzL1y0L8Si/zxeZzTR8fceOONv9uoi/zxsY997BoK06XVqahgvgBfkIQsZyryTI4cKisn40Ivfm4oGiPXlyAROz4rZ8PYheekoq/amKyWLGj3Rdjn9FVrvxOiw8IKJlZEE5UlT1krkQRgySWLiNjZHtZaCMl0ku3kC3n/+9/fKKMO46W5r971rndV5EHRVUQKlCjIF6k0j7MnmgfFCbMpiy/OSYeccxHTKqTznW8Q58hKoYjMnyUbIxTDJ/6VxjQnfWFOobz7CH8+u0ffbT6lZ4h5HZjrEYyBuQzPDRDwUyqT2pIs5zwQ8mVzjhzn8/F+WmyKHOm33XZbo571sP/ee+/9Jpo8i5P6OO+DPffSuSIT+dDmFsBhE4OcH8vyK6SASYmYtxHWTvK22kFQIrC0/I7cMufmTN8Fhq6H54A45gbNR6yZsBDoR7ZyQDA5WspgBuf7IenQh5SLO++88//UdeEvH/3oR1/2mc98ppGtyFmKDPZ9sE1MOnAk+HwtW5LBalIZ9ISXlHDWkvpkI1n5G7nhtlb4Lv7WkgxzynLobeqYBoZ4Lv6s84FyU9M+ghGYJH+j/1cbEEv5JJMLpf+btlG5NEfWTTfd9Houo77SBz/4we8jDUROX8KqDd8AL2crEwVRkOPNxuKZq0qGIsh+lev/SAl4WScmo6LFZIgxQjjquFztLrUQ94P4muiO9pjCe6MRAm6zTFexPo9yWpq5ZFkceYvnkuJA22+++WRy3vpqd9xxR00OvEStrKycxoRsZEdi5kaEdOBojSEF7vH+9k7zAAyq1cGKoMq9Vpc6xUjN7eTLxq6Fj4/o9wcYeMTAUF6EZSWR31di/kEmECYX9nmT24KUCzr2zjvvrK9SXfGhhx66jNb+IPMVk4IUdMxIlaP79PH65mwT41E35l6gd39DExFLKa7EbL3ZKE5Cb3GEX8BU8AEaclshvs35XV/6volnV8LHhVwcY7ePP59NTKVNNI1C0zwsoN8jgKwsxESv7PuW8jwIPzW7LmhSxk9/+tPhnnvuqRaZqq7+wAMP/C+a3pd2kslqJaZlZ2c6V/b0qWM24skUq3V1xUy2HIEVlNkk5XfO/l6Jad/boFj/x9DKwAgEuW0MEpgL+r4/F1LzbIM5+EGGDIUf85lZ+R0x34f2PRhttBJrNMmZyvEcluuskRCJEFfcd999XxOYQB555JGrOV2dp/8txCSK0uYmI7RkZBaO+DGBBRtAi5bSckIs4PxVpZhpV4s4CAYTOxwOh4Wx5QSartD/wdAc7FagEcreAtZsknkgUhPh7ZQTcubMmWsCE8i73vWuN9FGNk0RkfBaHsw8RCxUwcc97vI6dyOs/SHkNyFmKiJrX0jGwwaRmowG1cehpI4X6wkUN8J4leiDrc1YXeZa6XKdHuraN+YyivQwXsfcoAUepcJ4j2BCRXk+WoTk2kscGMU+b04ep+0k00nmh/VUJrwkLpPMLbfc8iuBCYSSRuggmX2oOaiPX/SmDU07rhRz0aPvgWbblT6SEDZD1hA5AqYQOSBt6tQVqSnnUwQzRWJoA9fgHF0xNxPpLvt6LD0CfR6aNqI51VMyFQfXK7HseAGLAHJZn/jEJ46vQf9Q+C77PthkpYXEHt/cpqDWKof7alUp6BEEVtJMG3StUy6pnKh/6XO3XdPE4chBH8LNBwPjQg54U3JQcw3Ifdqxlq8kQMCTJAsO49XMW+F42qvjOoTjKKyKQNgMFcB/ICtcFJsrXqGzGkf+wRhxaxqHZePLQZc6dcN2L1yb6w75cu9ScMxVSO27cB3bmbwviOWchRa+kGBoIQz8zdfF2UU4cCoYgU40Z2JgAuG5r5hApBYihS/bzsrySK2ElvmN2xHyRrWkmTbQrpmq05TNSHM3cznmg7mTxNJJTlpqpJzEqCxJMOgmkJDOdNl2TBaa852nsQpioaqqVHaWyOnZ5QXYkX5CICc10aKpAgg/7eHGws62Rdc6ubBuh7YvrY9kHYy59YWhNTFZdiqCtQ20PDx5TSkPZfRtAH8ITs5IPvMgCYSZh6cukTcTwDyENxwTzNK5XUD2IwO1EA1thXuXOk2tU49Zn9xr91XHpZBLl/vYOqDDiXn2SJmwGBhsZDnWY7JUlosyHeW7nHGEZSYRDSUTBiYQZhe5XK0UqmzOkuoNqkCarwEd15rZSN4kR3/JCRwDaBRt0LVOjvbt7HA4uoPfIc13kbLQHMFaIanoLQkp51njYDMV10lG5Ya1JYoI5P7777/qgP655557qix0Oujxj398PfMi54SE9cy8NNUJLxgVYCSvCRMt6om3E0nICmrHWb/bIrdOGH02JnZFaLHINYdjTphzX2Y5qll/tEhVzXccBJmUMImrlLEo4ziJnBeOwokUeYoTeS79ffjhh6+paSnFUFoBwRjlBxCAmgDHaK8h0KVOu0oQdDj6hIfz7gZDt5EmhzGx0IJ0ruOgHi1FQcmTy7HGoPxfBWGmwgNlgbLiJUwRImFt2zAjhWZK/ZBI1Uk2bC/5G/4eOhyOjkhFpFomq1wnO8p2jWzweAurAASBBUpBKysoNYgCkuk0YigwU1yZcmRIxOpk1bkzXIlxtMQ+jv5d4zkBtgWarSwtRBIJKgGoUaQ0C80EqCkL0v+9KkTeR6xASTBahJMWV4xqk+UrSd1cn4jVybHZqXKxq3ac8/Pyug+PXdRzyGtYZGDNiaVFs8pzLfLQBv3WINvSSirFQytYagpo5skRvBpjad/HxJh1mpMg2WVdc6/lpO9YGnCgrs2uu7GmkrJfOtTR92FBS2lgaLKxJp1CrEiI7IYe/FKsDxISalFKK0lVcBdINeo+IdUOuW3l7TkuvP2XASscF3M7kDgYMg0jlg8nYcnhWGRbUQofSGzGRvzbhqXwJgIQzC79IPuCLpFtThD9wU1V415vju0v64zaBTrMpZnLWhtEk9mW3G4zmEZCIh/IOfRvxJzhQbCSZt7i9T1wO94IxRbzfCoxlusVC5d/Q4ZE7wpLICnPq3G0hdVntCRAbf6roGgsVtqCBem6YGLi/BHOC6R9lDO4XpX2spVFEFgJFPIy6a6ts1U67XcqMPy9HhyupTgc20PzhWjaRixLXcrnHFcDbufvsWscaOFZGzkbBjs2wnLFb1yQRHPUY9iwC57lYGca5QwxdNt4288TUv5pfo7Y4lB4HGaiB8NqFCCFI1dLaVwXOxw6vFMxxJqDnLWTmIbC9rtBicM5aZaY2mBiboObbetrne/Rg8cYkqC1qdotWLkiuQmF6IPOMYHjYL/OREffRwDzlVVYCSnwJWSt4/FBsJ7UVAZ5KD4Qmy36EADbrG6JcA3ZMSS0ZG1tZt0UucQG5pZJK5YDgnUKIKtX8uCYLQx/a7HG2kWQYOSxctGq1AvqarnD4Vg6cJp2bXEojL5Cp7pEG8uRFaUlTWIow1daNBVeSCMDvKAsWBJDUEiGvfysgfjozrFPmLOJyMNuh4HmA0ENRDNRyX2YSKhZlRAx53kAK5Qm+xt0pTlYQkTLsOxm6ESXOAqbjZDSLpxkloO2EXsOxz5Ak6H4W8s+D2DWksdohKAFPWnvXE7yYUACYWisQ7kd9KHKUTyw5nzR7HgcO8x/i7LJtIVYStGqy9IEyZzNcVN5FmPUY58Izcl7t9DcA5hpHksg1Bzp+OHtvDS5XMK2YZZaraocPZRTtI3OeeihhziX74yaB8KIOdOt7whtdayg2PgCaDqpGOZdYgkJenOFC7LpYS7PZE59BwffGkmgAz1nSnckFit7XatLzAde1wnVGSvhJOYkx+NkJiPa5TR2TUXLuBBZFnb5PPuMxAo7qLv39f4w50GflW2u7UftRDN1YXk5CYg57beSI/1gdGBpoop59QOYnHLW8q0r0vOL7pg25iwo+6i7E4XDgjXvlYXY2iFBGcRj2SEx36F0yiMOrJNkwbLwWNiu1EA0DUNTyXJUKsewcPPc8jAF0+9Sscu21bSFlEzdBrE0Dm37CrUKKxY4tS0ITYVDeVOsqS0S71gGckbYPgqfNnb5fLwvHEPzWSC0CKyg+E9Q89DcClYit0aSmpWpronUICx/RwibWedYoLwwJr/gTWr7Hc2HNUX0WTcXHA7GXPrCrrSPmEzUfMeSGLSZelew1jpmrEsLEpZrKRb1VCZyhx0DvGnOQvLQbjI2R0snzWPq/cxl4iQwpHk0JuycFB3bQIuowoTBAJqGFp0l+76VPyIDnrTEcAYmhtdl4H1iRiQXxLHDfEHL9IUaijwWw86s7Mokpm7anZHpecjR1NIF6T4Qxa6z5p18Qzh//vyGthCU3I6gmP/xNxIO5ePxb163iXDu3Lk6v4/2nz59us7f4zVBKA+E9x8eHoZHH3306npFQvk3Z3RVwNQkWjQXkQ6B/jIBxW7Wvmj6EMd80VVoTCEaygWeow+oORaRKCy07mjaRsgNxVWWM9fcEnJxqfpcS02RiG3TblxmlzOJaBVGdjQx8IjehcAykavVDvH8twki8P64v1iJ5WgZmiPcis4KSr+XKRiWuwEVAml9KpRlPepr4bQl2gWskF3tu+ZDkWpXISZclFhUFFYP77+HYO4WWvDIthibCPq6vhPa8NDCZ5E4LJ+GNfhGeW4HRzUh5bYWHFWIBQEPrM6hhXDFkg3x5rEMrbKLDd112e9wOFpAkgYOsC05idnoWm5ICdOwB7AeSSe6BE6kixFbNYEFRftANtSy0LUJF+V3GfoVi2X28F3HkPD8ouHgmkn/0Jzj1kSKqYxzzT1hWY8ktOmtpPyXbolGIiFeAC9SM1bYdLprscOSREoxIy87Y7L8H469x7Yhs3MkERfO+wMc2ZOAbqOBYO6HFSWLrgaU25Y7gwlDnlcTHdrIUKPQfCMFmGg00mFw2FhuZqVjd+jqZ3H/jGOfMSS5s5COOclDQmZavosAcj6nLkhmeN6BxUBYEMUm04cLxTVBAggWLfpKlqdlps8ZLlTHgxU96HVzzA2Ua0Gy1coc14A+EIQWRUU5IFJbkXkfQfhiwrp8XguKzycuOLzk8P6NqUzkb82RjmqOFXkVDKFap8ArK2xp5TmGwS7a15/h8uGmtn5RJiaitZIEtYlpU3l62l8JTf7Lv+TJqJ3oKcEvC0HCiMUWxwgBw9KW1hmREJdAjGPV3wVVN3i7zQsyAktbA+RIWVtJ7pfbrChY1EjQTSGP0yDLUnWeNqG9WkVj52MeCDZGln3O3wlHS4yZVNj1ei789xc4uLZMWNaEiiEyfxUD5bk1yI+5FxpTmWBBmgOmhOxEK/w3AGHgdk0Vyx7dTmwQHzPVOfrDXAXqEojAyewEQ7/bsSmecgZC8hhLNsv9lvxnOR112FuFWhe1SCWA9oAxxAEICG/YI7E2M/nnjF3fw1gCLvc+u9ZvDoLbyaV/aDPv4txXbTLTU88Ic0ZkuVpYMKMhtfEgJAQNmlNdlhfLXtdIYx8d6HO559w6TvVefJCyHZwodoNYuK61eJR2TAoY6mvJ6KgGYpmYQqZgQ4LBvBIsl7dp2ZXeQR1DI+flatMPXUNw9Ak070sgWWhTtwcjJQLDeBFWuLkV2VXXwXKMB0EgtI3ihPkiHCusJR/SxShmuEFChZ75KNUtWa7DMTZ2KXRdwDskZKZ3gMloGdqiUWGduI0KQCyc17I4oUWJrk05KryPZPypU6fObEznrv3VgMQhb4wzIeuLry1lyILaSlgOh2O6sGTCvpDg0LJKtqOW2xFLKMTzUUZbWkbK4hTTWuooLCtmWEKbqx4rwCypRWdJjWVKjnMnMIfDMRVoaQ6YNGjJayufw9I8Uj7uEBkcVPJeYydN5Slh2l8tvriAaYgxjFcSldQ+tGsn80FyBjwDD4r20eHvcAyJfX+fpMnIyj6PAQlBk1E5ykIwiGPDB4IbMexWu0gsOgunEsbyNipV5N9QAzmHzaAv7vsL4ziG+0Gmj128qzyY1hIJ8Tg8J2QGM8lzsgfsBhqJhJqaoyUDaqym2dc01UmiirwK+jE+unc4HPsGqYFI4LxYsUG3FnGFzvKQMWhJRW4FLZFQSxTkQjDDUUsQRKdPzCkjJ1C0tBPHMFjiiNdH8Ta8beaBnFwMzRetkYLlNEdoLgutbERZrJe0tUK6YoXkmJ0s/wqGqcnjG9cZWAFpreEUJ3Vy7cjhaCJXYDmOYVlxWAbG8kE0t4Dll8Zt2vVj2oapyZQhHGgH8I3INT0ovphif3kdEHlBGS5G58iG4LntY3NdaTc+NDp1dH839gZjCEJLALtg3h/IdZYYGtFwToYW7RqUcqwAqViIbqGshU7Hnz17Nlx++eXHigASQUiwkSzIOg7DerXZIUshjbs6cLrCX0aHwzFF5OTeIWKaB/4uIbkwoFYBiYS4X9ajku8yN0OrMF4ct2nnWk5x+b1YOzjKkCYrh8PhWBLayjvUFpgIZDpEyq1QwMwhsUComDtD7t9Y0haFforVrEpoDhnVSVMe+xam5uRzQnM4NpF6L9zc1h+0ICUGzr7bZmnwmJk0NfhHrNDBjSdbhVh+CzxOTm2iQbPfdUUfob8ePuxYKjwSaxpIuQZCgjwk5ASKci5BTcuwomtT/SKmCBxghbHyuE+72RwSsWCG8DoGhZPkNBFzpAd/bouHNqBnWH5qK4o2ZTFCvwheJzXoD6yBWAfIgmJOF82hXjtZ1jHMKQ3GX4xlwJ/jsNh2oLUvA7W59sOcUFyLPLT9mlzWiCWmsWiym7etZCGIGGnIi2Jl5A3JCCw8rqpIyJvI0eHwvnEM19iXC+3ZxkJtte/aMVqZluy2gqK03wfaRblwsqlxLkghEgA1VaiEjHJtbQ++MDp8VqeOf2sx0I55wZ2oDu8D3YFrJAXDSoPbYhpLagp4LJtw/vz56jxaB4rXd2LZz7khFy9evOwgAAEE0DAYaIay7GnyeAZOBqZNVbzN1O7eWdvB22sZ2LWg9n4zPFgWykX7LIe6RjDaAFyup85ylsu3zGASMY13pRUSi0RKOWGsc3FxeJzbxZe03V+4YJo+/BntDigLC2NSWsuNoD0rXqmQo7Vipi0N1vZ6OvecEK+UgLcYTBIGmq948kU5DbwVRuyd2BGD9488+EBtHiiUxL5YH5ekwGRhzdyb41cJGXklDQ1EMho60LkimtZhqU0aJGFgMkx9PWXSKXccLhNTFfre1xxjQK7oGhRSSAU74XZLQ8F9XaNhG3NhabHAFnJVIG3h90YFwDZXlanM4+6jy/2GP38dTnTLAiZex/zMudqI9rHKxO0p3/QKiUDTMgpj+nUtdlhGa1nOckkakjxiccf+ojimCCc2xy6gDfQtU38Qa4bgLCD0myNrc9InkiYsLRY41z5mxREHI9JK7kOfiFZ+Tp0cy4c/+3Hh7b97dMmNk8eh4MfAJes8REoDqfNAsBAZ86uFlCHQnkYsJ4+VFaF9VWwx+TrWh8Q0DNdAHA4bSxpg+WDxWPiTjORoLM1iI3NFYu4Elt3oTE+ZsfgaJKdl7h/9vfTSS6vtp06dOqOasLASEjkxw9a2DaeOQR5oyoqpalvBOcmxh9h3AZ0Dmc6wy/bC9AbUADQnO2ormkshgBzW/N05g3SUzY3a5RAC5nykzseLyu9WlECK1LS6dIK/R44dwYX2fKA9qz6fX0xQa0nV2nTtmgYRIwJL9gZBKDn3uJEwLi+gXdQqwFKBtEpWFSz0nJIc81RX81VO7LRjv5CzXoLj5P2Z47uzlPcdI1ix7+YM4EuYYgqPk5qMRj6WdagOlkJVKDfECzUITXVq+ECC7oxpoza1hftN+oW3ZxM+MNGxTbt4mx5DkgXmyaEWYqVixMxSklhwewryuupkiintgLdrhIHOdM2PgTc+tGBywedoi6UKMhfQ04YWnRqUVAhtOpJCyVwPCeUgZqWxclEaioF2UBvBrjFYFb0VNjPX8Tx2EqUcOLnOeodjahjaDDQ1M5MT1PDg6CzNeY5kof0OhraCJGNpKbKcgy4eeLyIdjOVyaoIG8d7mN784M9rmvDnMg/kPqc2zxMH5zEZa1l8NI0lx68it60sgV6HacH6HzGnt+bVpw9rI6nRUlutwrWQYbGL0bNjGc/SsXtoEbGoNVhyl/NMGLT+B2/nv9Jspl0r4FxYlrpjVUwCfSANlgqrRnkpc5XlcHc4NLhwXAb8GaYhc0MKmONK00owukrTOrRFAiViWkhjSVvNdoaFaqqRth9NWpqT3QJpLA7HWBhTkE1FiLowny6stZOk7M7xG/NvLbTdMmnh70YeCJqetAtq/g/8jsdSDoh3SIfDMQdM2TRuCXsrlNcyYWl+a9wfIm3Bxx/IE9Chrnnl8QJW9FaDhMru8807HLvEEA7PseHv3LKAeSEb8lbAkt8SXVaEraOw6K9mP7NOkJVJXdCKS3ZMH12e1xjPOPeaY2Sg73OfL0mu7Pj2+2jvvp/ZEH1AW9wvRz7nRM+m6o9lui+WrwAAIABJREFUVrG2lm8CTVaVMqEkCWoXQLUpN1TYMQ10eVZDPN/UC5jbr2LTWXcpb04Y41numjxCZDqOtmVMGdKBnnsfWqSWZqKy/CYxX3d0MsVN25m+mpV2Ec1fknPjS8ES7nPIe+h7ZJZb1xwS6QtTIeG5YCr3PgcS0XzVsVyOHItRiNy7ZZ06KIriHFeoWqODkgAjLMcFcNxwTuW4PJ6bfpcv8ZjIiTjbR3ibLBfe54cFT2GSSoUICU1DKgdybRHexrL64OCg2oZTp3C+yCqAdqBpEpumqONEE5l0EiLztwRYztbhcCwTTh67gRZthd9jmok097ECocl/rVy5baUxGfoxNk1RJ781EuHvluPSp9R2OByO9kCNQiMLTQvU5LjUQKy8v5S2c6BVpoQsRiwwgEqEWgXvw9W1nDgc+4Z9Mum49jE8LLOU5UawfM8x2Y7nR90TsYtojJSqVDA6EpNHbiSMw7EUjN2fuwp2fw+nh9x8Oszryw3XjZGK1h+i0ryApEJNLeK/uGj7xoXW/o+xtRAfJY2PMQWTa8H7gSmQ31CyJmWeYsQ0EvxumbBCxCwWZCZ6zgW0sFwGO8mlpoHf5WIp/iI7HNOHR1VNC5iHZzm+c1wPOSYsWaaGFe5IsRYfQ2FdRAL8V2oh2sUkiWgLxzsc22DXQs7NO8vGVJ9vocysW8J8VzkyXIJlsXVMLM/v4Ojo6LDOKlwvlche+eqAg4MqP4S208dKoVftY+tpgvlYGbE1xqjGR1IOh2POwIE3+pblkrdBmfCWf7Ocl8fKsF48XzObldqa6HrYbmRWxlBSfnpjmxVLHLOlORyOecPf7d0Azf8Y7SqBg30tQtYKDc7BKpY8gs5xTiJkbaLKSFydaiQIspaBN4Gql8Mxd3g/dowFTRNBYok5xWNrgLTp1xsaiCXoT8LB7MKkkzyAowcd8iGijjkcjnliKlrIkjUhDFCSkNOSaMmFVmJgzP8RrYt1IDpopBbBv6WPQ7uwlvoerYzmWE+QYSpT0rEdvG0d+4qp9330e+BytyGS82GZurRjY5rJAR6AhIH5HVgYRgTI4wpjosUcQmmcU6TP6WK/cywD/syXA/ej5AFTIazIVtmeUlZLuR7TTDRFQB7XmAsLNQ25ShXPccUVR9OUFpEVy3hsiymNBvatg7sWst/Y5+c/tXtnX4ckD22S2liSIGsgmoshR7bJYw4034RkGg7nwkqjf0RqLlZm5D6OLKY4ovJRXn+YQ1vuuo7ev4aFpmlgIjcC5TEfhxakttaiRk20zHNmKtZACjH9r3TYyIppbBZTk5aO2D27D8fRFd5v9g9ybSWZyM3beCCvrekkZTp9KMcvCPKhfZTzJ2HJp9qJjxdASLarKhfajSx8JOIYGi5IHUOiS/8aQu6hBcgaoFuuBWugL5FrOaqTz4NiI8OTGoWKsjRVNeaMUctzOCYI76OOqQLNT0FxPyDkfvSBBIMDAhCQRO0b1y6qee7ZB2LZyfCD2HdNxAXSfsOfv6MPYLSVRRyojeD+GAkhLNldFmIyRYtlkLnYhqYdgxXBm2ubF+Jw5GJfBXTufe+6fZwwh4M0ZWF0FcprCZTLAWRyTjJhwzJVKlOZoCYhkwVx8XXMIcHK59zAHOEvx3zhs0AvH2MPUHcd8aYJ+CIyo0ho8R5gdBYqBatSyTYPgs3Qo48mrBjjYUUc08E+P4+lkchUtRDHMNCmXy9gvkFtgI9O9KCQixXGq1mPKmsU3iEyWCGyFjXysLQQ66awEg5HX3AB6Vg6kDzQhCVhmZ6CMYjSLEcow/EdO5AH4l+OM2YthGfa5QtwkqG8Kenk4f1Y8ZwFpSzvv8PhcAyJmCAeGzJnA6FZj6RcRyUg5vOQx2tJ5Lym0yqmHWghXdp2eQGNGOS23NUI9408nCynB38m+4c5RJBKi5CmiSBpMKSsl9NUYQ4JIpbe0YjC0kxUVqFyBsiQsCtjer2Vbj+X6dzdBOeQcKKZDvbl3dRksxYMJX/LY3g2EamtaMdLotGucRCzb+XY1oIyM2RsThaPgpkOcITi8Gc5Z+zL/Uv5aqVhFDBRokYCKPsLJbEwJNq1kUiYyglhpB6UtuSinLteg4/iHA7HmOiDgMYgMalBaCar3Hppx6QG/PXeVEIJsphGCNq0wrherzVnfZubWipiJsOxsTSC31dNeFfPcW7v7VzqK5fTQCe5FvEaQLuw/BmW8qCF+8py67mwYkknKSbDhU1CptYRKzMopOVwOBxTASZU74qErCgsqQRYcpO3o28jdS1LqdiYCysnCsu6UIhoJkgy+MFphHPCzeaGqWoXDsdUsO9+nBRwMK4lC2pyMycPRDvOWgOqLsdykEtW5XwOuU0jCNQ+tNWzLGhOIPl9SR1ryUQyl6zo3Ig/J/x5YB8d6Joc0UxVIWGaQtcC7+O/tG4I5X2wLG+4MvgL2tNifwMkBGJuRy5ptIG/yGlMpY36qoePRh2OTXAIboCkQQn0h6CPOxU4pflNULOpyEdzvsTCt6QNLYh8ENRIgtBEpEayBEyZzJxoHWNj6sQ/ht+iL2hL0eK9aT5rlPPW+VpZlnWo8oHEQr9i0FQeabZCs1YAraUt9m00uk1EVpvznAwdU8Eu3vE5ZJqngKsJWvkeCPSVtPV9q2G+QVFNJHCfFSuMpKBNbZJa+H3fsGQBOda9OenEMbSw7Fr+NueNQQBjkQ7KWs31IIFaR8xkhd9ztJQ6Ciu3QdCEJQkhFsKrmbgcwzrUXZhOC/48HNsCF5PK0ThifgytrJSfRJ67ymEZbb+VNKglDmpk43A4dg8nse0xpslLrs1k5eelIrDk+VYyYayfNIKptm0MqWFIn4c2Q29X/4djWLgfxDFH7GOUnhXhqpmntG0xa1OXd+0gdmKhzCGP+3heePp9FI7CKui+kGAkGTqmgb5zbXLKyr3m0vKAUti3+/Vw7Xaw/M28XpN0skviwGhbqYUU6/WfeD8ldvM2aUlimU+5gefOnbvioE0YF9rFCpixsQhFoP9LsQyuvEmcAj6XSJbewYa8v30TRlOHPw9HV1jEgdvQVRALjsJjLIUhKH6SgLPxYuFWcklIvAjMXBJWtuPUsESTiZuBHI5+MDb5xxbvQ9LQyCBFJqiVaOVu+EAKmDveulgZmguQyFwF1FTwpobITl8CpjQadaKZN/z5LR84TZQGaYpqE5KL+SG1lgFEJUnkAMkjGisc4iFgsuA5aBuOYZBLim7KsbEPpi5//u0Ry6+TIB9FToivtg2tTDH5HZ0Ly3Keo0qkmbVS66Q7HPsIF5r9wNsxD1YCeBGZ64qRyjMJHIUVgDTkNi0ZBS+G8cOo+kiG9FDe9ojNFOBwOHaDKbx/KEe1iWxDhgaLLohgWJIQG050zWylkYgWjYWV0GKMtcWmpm7Smqotecisdcf0sPRnvev7W+oADHPwJKHkJopLWOSjcYEahcVAL750onNlydZWRtYIkbCWtN1nOCHsHu6Tc8wVlJ8h8z0Q5Xr9JmtqEs1chTkhQUwZz9uoTNpG1z537ly9r2HCioV4cZ4HHyenbLccO4ypONRT4WyOdPt5uzkc40EbmKdMT5ZvAyNuLX9JrKx6Nt6UYMBjLJXJSm7RJlocAj6i34QL/enA+6djG/DMH5o2kdu3NhLAlTwQPN7CyiqEoTnOi/UyiKFFWJk2a+9QcF/BuPC2Hwe5AwV/PvOG5XfW0iu0vxrQhBWMdUMkiqI4d4DZ5QGiqhBYYIxIUqTimBZcU3FMEdZMGUNijGvmACOmtLw9bcqR1P1YWeuxwXhZloeN2XitBEHrt0QsrV77jsvdOhyOjRc0u0XmSP45dY4lvPV9rb6vOQRSxIF5eRiqa91vTANByLJWOfHCGnu1MUdJknCycDDmYEpxrcwxJfAsuSGSi4dmrZhFCc/HbZYVirEqDRUnKM4ZK6HNMl/J+OQ5rUjoQsNGG0ddn8c5+oW3+/yRyjIPinYigQngOcAyDgKoOgjWHmSuB304GiAI1kO1iuOVtUo75ovccF4P++2Opbeb94tuODg4MAf2QfF/yGNSba7J8KCEDpMW9JjHPCacPn36/pVGGjHVKCi2tjbwCCnH2HAzajvMWdjHoojmitRaH4wUeVjaSRv5vOFE1wqzKqmFiVnhZVrZDkfbDtsXnETcjDVHsBXIkqVW6K1FFqilaOXFsOFER/tZKjvRsrdp2x2bcEJ1OBwMKxFbolTmIAyJ9AsNmomrrTxqZKJbscNWZiJelNZEj5m2LCe8ox2GImQneodjWFiBRSGSK6cFJzE0x7glgy2TlnUO8oJ2zY25sGK2MMs5c1Jy8yJaRZ1EdgtvZxvavEKIIQIBPLhgutj1c9GiU1MRqzyxIfqTNdmaIpOYTNZkeACr0wHGCcdYyLqA9d3SYHbxkJb+groQ0uFtkg9vq2lB00C0Gc0RWjRsiMhniZQPJNVHGrVBgY+/LY1E+26RB5m5HA6HY5+QO/9f6jjN3GT5rTX5jD6TmEzXfst6hGNCW53jQkk1CkAgPLe8nHakTZQVn1/PUV9uVsjXZ3D0hbH8OGP7j9x/tT2G1sj6kHPoOGekgp0CKASUoyfXFZEftERh1BdxAOWCBI7CSl1QnhgU5oqVkVLJhoCr5vuLIZ79GMJ5yGt6OP1yoFmJtDw+bbAvYWkwsejbgFOZxNQf/K0xnmRHOVeWtO1NZXEphyO0yAfJEeiuBTiGQilmAgmRSFgrghYJhuWyZs6SikIKK+0C2slaAkssByQkCGIu66M7HA7HNuhTxrGJKUR81m1CexmSPHBN9Zjj/kDbqBXMBRXGvFklZKHLkDQtPM3hcMQxt0i73Lr2fdw+QWoNWlu2SSKUxKJZmHL636oM5caJeCHt4rGKSRXJMRzcZDJf5D47f8bbYez261MGslxFDUGzAiFBSEhTWMzkFdNaao2F+SOWCxLAhCUrGcB/IklI83f4HETThgssG942NlxbGB6azJVAjSLlYgjQpy3ZHCPBeioTZC+8KF5Qq9xGzseaLZ08xkMXoWcNIhx5bTd1+LOdL7T0iSDeWelUj7kk8PyguCFy+snq6OjokAuhuOBCrDaIF+V1QSwNhT4UH8z5JOZFBySS3JHQPr1ELjAcXbEvmsVc7vOxj31s/T0nDw/3sRXp9OnTdT4I53Vwrt7Zs2er7TKCVq4JRd9pXZLAGohmB0N/CBOLpoFoobxBzDWEnv2p+0Zc4Dq2wdT7zxBO7Kne89IIkGUwugssx3pWKC4M6FOWJVluI5EwViHLuW51HJn3MVWHuhPFNLCv9nPvf462OH/+fG0pwoF7TCajQx2P0dwYsfwSxkpeVLtALGQXv8s8EZnnITWQtkTizrk4PJrH4dgfkJlJyupUqG1KjlvnoE/FVBRSgkUSDJNAKiGFj5VkMbewXhe4/SC3f+0rvJ/Z8LbJAwr5XLNWAbOGSGiBUxrMBaXwIngh3B+Ekz1A2K7UQtAf0hesqINc7Lsgc/QLF37jYwk+HATJTqmFSGhmKi2i1grpZeD2mGlspYWF4ckYhaUVHI0VBvMVZlNuiz7K8he+CSdURxt4fxkWLJ/I/4FyGnM/Yj7rAHLekucSmmysOQFtZMhamm9EqxxqFaxp4OparI30JbBd63Bsi1yNeKz+4n6u9ljiu81ht6kcDZTbWpRsm75iOdCDdKIHYCCOD8Z9tI32ccww+jn4POkLCcIHwrkiDsfS4blG45S75IEhRWGhk1v6prWPtvwtL4vLMpyPkdv5eJnbJ5WCqmwuUGM1fBDo7wgJ57j+IKfxcH201h2uuTmWhjn0acs3EZRp3YPh97DMU7FcD+3YOqkwCOayTgzCbyE999I5rs26W6jzzrdpsmEQIw8Xjo4pwgc8Di3FwkriDpEorJTj3PKFaKYs1fibii2uT1Zsx9rC8FjJsV8G695StkWHE+wQ6NPH0Wf/9Xdhekg5uLUIWu24oLzL2rGp932lHWSF6ErHTE6GeSnWUh8bJWRX4nxdGgM7toe35e6xz4J/6f2N1zG3gAP0LjJNahpaWRKmBoJaCJqwGFqklbw4k8wUNA+JGJPnamCO/p/DlOEj8jjm2j5zfddTiYISqWeTIgorz24VO8hiMwmcqh2TDec6hbsLi+0xxovZ9bn1uTa6w9twl7Cc3SlY+X5t3tuVphmguSdaAERjYUgZluuYPvw5ORhT9VfOpfy+YQ3opdVEu6fYPjy/zTM/sNhLmqz4whSDzGn0ElYUltzOOSKMnHmxxnq4LkAdfSHXHOpmU0cOKCfDSuYOEAGLvmwrSEiu98FuB8z7k5DLemxM5679tYD+jwCz72r7Qo/rgfgL50AsvU/0oRG4CWm+aOvL0IgEIbWT2H78XScS4okxNUfTPhiohWgaCZ7jmBfGEj4u9MaBD9KmBc21kPKBSLlt5XqkUhswMqtOJIzFDKMJC6Oy8Duuf46z8M5tSvcYXKA5ctFnnodjXuh7sJzjlw4JrSJHWWCkrFIr3IiJKNZFrAWisMEkaUwlJ8QxHUxlhLuUgU0unNTmCc3RrSX+SYGvPcNCmSRX01xaJRJqak5u9rjm85gjYbjK7kJj6vDns7/QZjK3TFqWpmFpEwgt7w+xId1jjhbrghhtlRrN9TXam1pyYlvMlaxy2ryNmj025qh9TLHf++BrN7A0iqBoJrkRgCEi4zXCqsouIA8kxlJYiCQK6wWUuSFoypoqfHTncDimDHSkW47xkNA2UlqLdlyQ5q8yhAOtII4F5hjg06dPN+KMrWirAOSgOdUd+kNxLBf+rB19oosFwJrXisng7Nmz4ZJLLqlkvTYhLk5fde7cOTru9EoyD6oyMY+/poFof51ENuECZX8w5WftjvT5Ieb/iJmsMBRXplRYpitMTlT2H9YmrJTtCxlLVsDKBcHt2nfH9NCH0HOh43AMD5TdschZKcNltjnulygT8xluLGmLRKH5ReqTFYKIOdJlXojD4XA4tkcsz0ODlc+ngcnGwkpLIETHOhMLz4lSKmuhWxVaKmks1Qzl5jXHvmApfV1zomsKAPoxcsJ5k3kgVsywrIRczwPtbJhtbq1S6MjPInV0h5vO9hf7+G7F7lkzb+Hx7AOxzg9G1Gy9L+b7QMHP22lGXmsGXmsqkyF9IHMQGk4c22HI9nOTqmNOiAU+BdiPCoKVcR4MU5hlwuJj6zcnNgEXHiOd5NZUJloEFh6zL5gCefRZh77Kcm1hOIzRtmM+z30coFnTmchtsTy+WHkSUSe6thGZiy7Ga4FQYRQrTHHAtK1mIrGQlDZPVt9TuWN9d4l91iZck3I4xoOlSUgXAwr8WFI4rS9CZXKuH8n0g4MqPbAOhuIPyXziAPKFHx4e0t8zB0HYxrRMRgbbyui/YDhhuAxMRNF+jwaq6sJkYO6UBQ4bS8xR6qtfeN+aFqzMcy2KllHA5IkarGRDlvUaAa3wwklH73oXZ6kfHKzCUTiJKSaGog9CaiApE1aqDrG0+yS2fBf8ZdpvtH3+bqZz9AlN67DCeK1pqrTcDiuYSvsu0dBAZMW07xLMStVpxUnGoib82/g/cl5QzKoMCns62mOq5OikPR6GanvXmrshJucs7SMoMt3StnP8KhINDSTGaHKt3SDIIlSFrBq/YxXcZlGpUlmNK3azU8C+viQuHE7gAxtHX8gR6gHIBMEaSCyD3SL4DeVAC/nKqQQeQ+YsLXKrDWHkmK26wIVZPxirHV0AOxyb2NX7KOU3csKB5gjX/CHaSoO8jzPUMRILQ3i1vJHtUK694mGj7lOAax/9HOdwOJrvljZYDyAD5f6UX0R7f2P+FcZK0zpSmYkBzFpyf4w8GP1Fu2w2EBOb5Y9xOJYA79fTAFpYxozka5OVHgMqE1J5QPJZrVarc+yz4OgpOkF+54irQsziqOV7sMCWU5poJqxdLDS/T2YPFybbI/fFd3OaQ2KM9ARNswgKSaBcRB8yW4QoBwRlP33kOlB8POWIyCjblWbCkoj5RfAcK1kQp3ePpcZrSAnIWMalox84STkcm7CWrxgKKWc3koYmGzHISXOqS8gAqg0TlvwRC9lFZzv7PbiCkjxk5aQ5a0MbyWjvWCTAlE1ULnDnA5/sc//Q1/uJCahDk4iW7I0mJ8s3IuVmzKetmKk2rsU4SFVWOsbl31gFQoSZGy/rUbNR2qDBujtKLXdScDgcEuj/2OU8f1bmOB4TFJLB/VIDyXWiV24MVH+sCuGJku00h/UQU0OYGofLdccaTvIn6KMtxjQJz+VZ4szkQ8PSFGLmK4Q0S+XmlmC5lYKhEYbmD9EKlNOWyEREbFjNJ8JmMSSfYr1wlSwvxqwWYkmHKeSEry0NLngdjm7Amce1qCwZWKStm5RaU4mhJXtbYbulWAxww3exvoYlI9GahFnuteainaTZ2RBEHKhxyKTCkKHS0eGFsT5v6uZi4cYYC52Kd25b/hzhwQWOrvC+YwMFPua6ddFK0MEtYZECbkf5hySjaSDWoDk5nXtOB0FhbpmtJJFoPpCmaatosJvm3NHqwbBu3Go0dCRZ971tRJeP5h1DI9U3vQ/uBpqZHnPgNPmX43iPWUFKZTEpa9CsyT8sM7U+iGUaOzg6OjpkIU6aA2kW9Jtjg+lEmjMePfEUD6ytPmgtJIUVpDKDIuxpPnqrIbUb0mKf+V4sJkdNCx+IwxHD0rTTvpDbJktsu7byT8uTw/Nkfh1DagVopkeTv6at8HdpJeI1QNgaxLKTtjMnHM+8fhAeeeSR8LnPfa5aD+TixYuXNebCskbusvKoAskG0SKvNKbFdXg17z8yqvVdq59sOI2VNQJB2551XApzfTlS5DkHcnWhvhzM7Vm2lX+aliK3oW86R/4FkKXWsdL3LM9r0+a1lQkLsNQWbVvM3BQjGDRbyTpgo2jHWdqC1sjafqtsZG/XSBwORxek5J80ZWmmrhJm9NAGtoyY3Extw/JiQVXaOSu5AUfhmi1NFqY5jGSj5KT5pyKsYpEEamME3c6XIkOrXvs0qnXCXA78We4G28g/awCOUVyW/JNaRgEpFXicFYUljwkReWdtVzWQlFeeK4AOIVTLAjCv/J5iVO13DiMWQWdjNG3FrudwOBw56Cr/NF+HHJAXYnYPTf4hIVmDfk3+IdBlgGVa54TjubA2zVfaCVrmeRtgQ6Njx6q4tq8Ua7PjDWEZWkNaZTscuZhD3/H+PR1IzcRytGsaiaYpoHzkoCbNzyuBmkpKZsbMWXzsAY3ZLRUpavtSWFSLh7aiEQolIcaqrHaDRYi/HCnTk79cjm3h0ViOVNoBDrRRW7G0Fk7QxvNzBsolpENggBRHYVllIwlJwtkwhaUqZzlYtJu2Yps1IsHrWo5v69i25zkcDsdUwRqKNnNHTAaGxGA8hE0LE8PyNbdxwB+g6YoLJQZElYfigil/Q94gMVkpci8Ycs74EJkbq43w11SqIeGjS4dj9/D3zoYWORqEvNU0j6DITsyRQw6QSeGoRJC5bK3FnFlhZVJ+AvT6o/lLkpBm0sLZfR2Ovl+uttjlDKoOR1fEtA4tKMkySQXINcEAKus9Un3jmvaBJ1m+EM22Jiueo4rlbHM4pgrvr45dITftIBbyy7ASCWM+aQ0HQbGpaYl1FmLRTDEfSZ9wlTcNb6NlwZ/nCfalLWID7thAXzuX5bHUTmKauLV/w4SFlcphPe1mEDEneqrcGPY9HNcFicOxf8iJMpVmqVjeHZ6nHWMqCVrBWuSVFn+sXdDSWmQiTU7FckhhiuThJo15wv0gjqmjhFlCJHLdARaRoAkrV45thPFa2ee54bLSi69lafYJF9YOx/DoU8udisa8ZNmRyq2LDf5jZWjYWFAqxVoBiCb7QpFlH7fRQhz9wc1hDsd0kYqQimkPbc1WKdnLdTmIXQDDvlawFC1vl2RizXuP3x0Ox7DoY0DQ96AilvDW5hjHZpsFRQmwfmMeiHacTMeQ+3mdqMrShBWxtBDaphFAziyTuRmWGlwL2R45L6O/sMvCVJ+n97NhkfKN8G9cIBBz+3ItTAeaWhRLTgmhORdWbP4rRhvNY9+jqtrAicExJ7Tpi66FtEPMj6Fti037rs34oeX5BfSBBMXJspl8Egnpglklcari3Hle5g4nwH7hgmQ8TL0ve9/QgSG8GNYbOjrNEbUPxHK8yAtrc6OEiBkr12TlncDhcCwNQyVOa7D8HpZvG2fjtSKzAsygjlih9177zQXK1bE2CjIWUZHbcJUuR3c46faLXb7sS4T3x3FhRVBZ5ijNhGWaqZRldet9GnOhR58/UgNBf4cWoqu9lP6iOhzTgAv95cCKoAqKYiCnJclxllurHwbMRNcSS/jCGKKrhefiilvausBDaSDud3DsC1zwOyzEMs3Rn43+EMuBHsAsZjrRtQvywbQOCO+n+eDrAoTDXGokKNB5vnpcJ8QxLJxYlwUnD0cMxXpdppRGoi2ViyYsqUCQzCfZTjxweHhY7bt48eJlqxjjSGiCKMccNZYjaVtM/UV1YnA4HAyZ9Ie+a8sxHpvyRJ4fy3JfBcVGJisVS4u3cj7aTFfi6I7cNvW2dwwN72PjgtvfGrBLYmAfCGocFlHEFIsDbaN2QszZkpM46AmCjiXCTUqOKQBDc1M5Htpx1jlWhFdYr4n+RCwchT0RAlWO1z8/d+5ctT66hFyqlvwcF48uctJ6dG4W3LbLF3LIa/WRpLPNuW3Py2n/3HtKDRQsddgqO3fg0WaQgtfIDe7IXY4Ar9PXcTGLQE69YsLAKq+PurcdQOYcj8e06fNdo476KL9PyDYg/0QQ5ikrLJdBx7PFiL6zjGcHO8lx8n3QR8p8Op6+Hx0dPa+RSKg5XlC1oZOpQK6sbHR5bBGKEIqTstDbPxZpOHT4M3BMBUP3Rc1cvzRoEVPYBkwW9Dl9+nQjgpbIg/aHdeATm7w4mIrL3YjC0uKHGbgEojzPVIXC5hq9BaySNYYOjkf7AAAgAElEQVRpaw4daImdfM73NMUcpim055xM05jrZmEOCc99aVwaUr7v9fcL0bmw5ImaGUpzum+cF+wHNVbH89H2dvD2y8MuRtJTqs9ckKuBTJ1EcohQHsuw7r1MzMLLIcKyvJWWTKKdKD33WGk8DzULNFdZDppdwF+i8bBPbe/9bHpo+0zmOmtG7D5TviWU05pVSvi7jzUQy7GmxRIHhSDwXM1kZd3YLv0gY7zULkgcS8dSzcFysbw5AH3LQRmwp2RxTAPR2mOlHWgRBE6mGFMFLcKx2G9Ic9ZYTrO5dL4p1XNXdZl7SLkPTPLRpa1iM9BOCTHfMta/jCQEBihL0z6CIsNXGiNp2+SFtWMtn4jqF8kMRewDY71o/oI34eYrxxyxhEGglNFtLD5acNQGgcioBIttCjEbr1Yx/I0ahxWhlXMj2zxAf5Hnh6mO+OY+i7S/C+0g89raYpdtrQ3gc+psyfuwrj+nZch9WrkHVgEBCIBigSkGWOZ7HGcKbs7iGBT20m4OHfhBafy5mxocrn0sGX3f7xDtZwX5xDDHAUOhzKiLQNluyVvKC5E+FSmrBbkcNKYySQnvTbsYCH8ilMaSt+XGMdoNaRoK1smJxLFkWBGQ+4Sp3D8uQTEnpOSktV9qHBa5BJDPVWRuUDqvpRmgGrNBOAH36+TEyYXatSXhjOX83hZLFgRTvbd9F76OPLTpJ1Mnj1gAVOz43DbQyIYz1+s8kGCM8rfRADS1R56OyYXNspuRAq55zBtOOONj7ACVIa7fpsxtorCmDE025lh6tGNwhULpA4o53mtdzYoBzjU9hQTZcJHph+m+kG3ho3HHkpGTOtAn5iR7Yu6ItoSP5ireLkOcG2FVmrOpVNLbLVaKRVhZN7C5bbPyDkffGEIo7KqvTuGdGFP7cNjtjK6BXDMXLnErZx1BeS/Lrn0gDOt7qc6eW25oLjHS0ExSKTXMNY92GPKF3VdhMPcQ3qVhG5mwVHliyVFNlqZMWFbwFEfjymNWSBJ4olYRUcVoha3KpuCjFodj3hgjAKav681twKBZjbYtR0u3KHES3WKdSIgVQNtXqAJ+D2qWIhaSiPlJ6u+haQbjsnl6FDlV/FxDGvt8afaVRLvc95BttSthMqfn3aWusZQAHzBuh1TCX44ZC6du4Zw/lsvyeF43pAiFPp17zEEeqxRub5RRnmzTjtFIy2oQh8MxDIYQ5jmJfNtct1QmEeyKuWsf2jZLtiJy2g8z9FeFkTRSQt6HxXJaZTXHe+zGu+x3OPYVcxxQ9VnnrjJlF9h1HVAuI5EWMMWJ5QfhmXZT9ZeWohCECSvmPMe/lqNcIyKLgFLYNpHQCcgRg/ePTexLmyzJopETrhvzcyNS7giOzmKs8ASNIOqDIwtKBdBa9FyQvJBf6xiHw+FwOXGCWDqFNgC32qo5x6F9HcSqdk7A5ImMHHslaiB2JfTzYxWM1WOpcAe6Y0lwR3m/0KxCmsy2XA0aYsv3xs5dleUmi1kVk576nJAvWYHj3+1JIha77OgHuW3rz8CRQwTaqNf7Tv/ApEFGyozFiD1LS75jkEF0QalY4SkTVKwM61zvZI5dwEfDu8XU2nuJzz/lu9CCmmLnmCYr0FRW8gTNBIXxvxZ5WFFZwRiBFOsFqmKRAVpDOBxd4aaU7dC17eaa1zVV5JAFJv5p6RJB+LUpt4/9IJTzxzkgp06dqvfTX/p99uzZukzb8LVGrAKWyakM6Rc1x4nucDjmD0tOTM3iMPccEJTRbQbmdAyG6DKsoKkgZ+PFSlgXimkV9QUSi0gFQUAyjNhJxNEW3mfiyG2fPtsxlxhi8mYoLKm/YApFG2jnsTYSC5JCEIGci10XGSpmvrLOtW4eK+U+kOljrs/IiWY60BLetsGUnu2u3482ZN21TCuSqyzLS1UTllWAlq1o+U20aCztOmOMQhyOqWGId2AM7SMX/s4PC+uZWv7tIEx4OVpN7UMJEUHeJkLL0iRySUS7oTnBR7jbo6saPhR8GvfdwMmkf1iyXP5F2awFScV83QFXJJQnBcU8Zb1QVh6JVnbsfO9Ijn3GEOaIvjCVAVLbengCsr3P8j1b8l/BhY2pTHIqYEVi5UZWWRXuC64NOBz9YSpCe6x6TF2eWCanlGUHB+44pXsqBJhW+VhxyG2Ow1ursKa5JBLOa4c8h415BNa48LZfHsZ6pru+7tDXm/K70SUCS57D6zrJEF7K8+CcELn+E23n34eHh3V5qyLo9i7N/yGzEJsN25y+nco8YS5N27D9LQ6HY3eYgoDsWoe2JptdYVeyLBb9qmkO1veIhtEIiNKwQsKwQrYw0aRZ4Obi6yf7Ne1i03Huo2CHY7fwd245QFdC7gBd267LcR1EIIearUszW2nTucccMJJsLMf6Ehzofb6Ic7G3Lh1dIrCWqEX33bfxs0ssue9qfS8mmzWg5pHyVZdleXqVysXIicLC4zW1J0Y6jnlgn+3Nu8C+OH0llvjMp+J/QpmbGqyj9SmmxTTyQHBjqSxJaxGApQJZyI3UckwL/pyWhZznuaRnvst7GUsTjflEciK0rOAo7Rp1HkiKDGThnGii7WuDAuZwSUWB7Qu2bQNvQ0df8L40fWzjR05pI5acx+2r2E7NBBXLTt+wkQX7xrDsudqP5/6iDVl/F0IOiW3e8aFzx+aIto7yFCnI43ItS2oiYeyCQQh8NHlhgqGclZfDd2XFtZvZFnPtWP5C7Df8+Y+P2LKuU0Ou5UgCB+1IHpTrEYwMdfJ/nz9/vsoJkbP2rjTnCjKQ5ZFHB7xmQ2uaqk7O12xynguyv3AB2g/2zbehYZv7I+E4JyLpA6n2wkx1efwKmYaR8tprYbgpbcYKNdMYz+EYC0ueRHGO71ibOu+DDOmaO6eZq7DM1CAel/SIUq2lJnV5SDnahWsgjlz4YMORi9y+wgOHKQ8gYveScqrHImmlSSsmh6V2tlqtHjrQmEf7vlnxMj3plahsm9DertjnxCQXqA5HN1iEMcV3KjaQt/I+8BiOqG0LOgfbamUTxCZ5yNkac9pWYzT0p7jWsT32jTyWdr9O/tMBTyI4Z59saraQPu6rTiTUoqe06KqcrERMSkHVSLs5h2NqmLIT1clm+DaQo+wpy6tU3l4MWgJhqswg3g1ul8ZUJtr0I6nM8ZSqFKJmsPlO37CEF3mfhNESBi1OHsNAGzDMLcE5lcOXuz92v7wEhwS13DkugOeHl/HAkgQODg6qz0lGeqk2tOVXsSraNarA4RgKSwzlzH2/hnoPh36/+xigas7luaGPdj59+nRjjRA27dHnwoUL1bZTp0491MhEDwppBLFWrsTxvk2zViokVzOFbfuQnHj2B12f9T6Fd7bdtwuMYWnoM1p06kRiBUHJbbH2sFwUxXoZj2DlgWgnMHIY3fKRWOcsQfPYR8LaN7/VknNBHHGgH7gNxjB75Q4crHcYg52032GtSGAZq9DCBhYUjSHF2OgjyTnXkQ/XvqaDfX8WQ9z/LsxucrCgmd+nDhT08m/XaU4wYVC2C7s6AhNIqUxLgoXlAlWlbSIFpoh9FxL7gF1qH2P7JfrCXMkDgdMw9U0kfbcTuhwsq5HmomCkUjli0birnPZBh2LKDKVpNFZ48NywFK1pn4jQSX9cbOPI3jW6jN5TwIjUlEBvWzaWL90RVkBTCiWkYVjnray6IytpNy63pzQPvDGtUR27gbd1/1iKk3pMbON76Ata2kIffo1YHl1borI0Beu6WshuKmoWwSYttEit5ImoOaANLO7viM8hT2uDxDpHV7Z3YdgO3l4Ohw2ZKNfnu2IREV4n55oop2PnWxYiLE+rbw4pUWsd8sHsZcdwLY4Hpvhf+s5OlGbF4zdPa4NUNy6Ixp3o28HJwJGDtv1k395LNNFLEmmLmDC25F4Xa4ymwWiD/mA8/3Kd30F/pXZBsp3LoO+8j/L/mKzo+9mzZ+n7wUoyY6rBZEPHbG94A40bVyZgdEHoGEpo7apvdan/LurmprX26DOIAgV9zEoTWvheUGZbAVDy0+ZZoHzXzFxlWZ5u5IGkbGHNyRS391+4D2Q+8OczHuba9nOqN0xTvlVZMQKI+YLx3KhFR1m0TyIWUWUBCSnnnJV2E5bnnjPSke2sm445bLTyHdNEF0Gwb4Qzp0ijFPZ1sMDTlfepgcQG5bgPZWWuTNTkb64piyGXqQ2ZCkXFCZrAtwQ7Jpfk3HSKKR0Oh42cd2aK79UQhNqmzC5tMoTpSg7QNQe6djyjrckpGBoD1iUocpv93KHFdek41YQlD9C2pUJ2A7Be00+SVTdHxsNz9A+fwmT32IY8cs03YwCJI2VxyZGr2j3GiGmbtrEc9WLb+caa6FrMMF449yZtO59rIwhvi/w22CdTp/eLOKz2mVIfiWkUllZSZuSepO4x5TZAWc8mLMvRjyS4rudpdTZeraLsA0ndQKqclF2tLdx3MixciKWxJP9HFwx9P2O2Vx/yJRZ9pbkE0JxlWYJkOTFXQo5GwiasXM1mXc/z1XogTAyU5yE1Bs77wMKq+OGgq47azYcEcbiQcuwL2tiX9wFLv08p/yxfSIjIR/RJM2KO8xxzX7nO/6CcDl7vg/I+eC0oyvOQx3EAFR1D3+m4ixcvPmYVIpXXNI76b4ivcsWZ59Ixf3K8rrY59hP+7KeDfX0Wlu/LEuBdUEKYLJqqLH9Jqg6WhiPPD0AwWL6meVjKgMTKKkRWLgCT5jAeZ57rFdEbwQWJY25YUp/tci9LiACLYVvySJmo0NSkEUfbOmiRsAGIAc1dWA9LxiP5rKxCrEppx+Wwn5wLK/fGczFnP8i+k+bQ9790H1lf7TcGeWwTfdXX8WHgyLuYbyJkaBeaZpAyg1nfNWJInS/lPk9hpRKIVgjGBsdseI0yQrPBqnNDk+G06zkcjv3AtuSxa7mxzeA2hzRyneyp42PfYw5yPK4UCeOxcOSNKCwN6Muwjq8vGvQLamYqj6JaHnxQsHyM+Yzn2L804Y6+Yc0vkipLIqddciK8LNeDhhUeIFlPxgZr0VR4s/JYjXVjyNFsHI62GLJP7cK8sg3Gep9y3vV9gWW+Ql8I+ju0gXpqsK3Jadyfs02ey1FZlpmvsaQtFoAnFZBoYqlYGok0Gsvwh7g2sl/wAcNwmHvbLqVvWOkM1nGx71hOSoa29Z9YTna5jUN6GTQX1iEfzDv4IGYfeRE52ZgM1YXqqJWof5dOFmHPBegU772NM3UK2sfSI6CWAnQBWP7kriYorf3RciTP1/wvuO3SSy+t/p47d67O/Tg8PKz+Uo4IccNqtbpgzlscs4vVlQw62/F0JZajqG0kwtTg5LcdXMjEsS+mrqlg2+nbY9D8HLEw2ZzyGCmTVI75K2Zi09AYZBViOnfrIl1UsJzj8dx978S7gpOfjqlMotjHe9CmjCmSVdfoq6nJECQLuT0oYbVdhHyOX2Sb/fEbPDZhnc65UIDp3GPOdLk9N/R3TnCyGwdt+5E/p2lhSPKY4z3nDrItLaUNOWzb9gyprZVleWlDd2sTOpZjR9P2cY5I28Zw7DeGFB4+hft+Y8rP33J4a79jA6y22k2uPF6lMsSldmHZCo8vpscwb5RdnpwzR83ER7WOtlhanxnqfrYpd+g27lJ+H4PitrlzXa6ZQ1IMSbbH64GEvKlJaFucqdNJJ7g/prU4bEz5RZsjhnSitsE+m+fG6tNjaR+pUFqJWCK2dpx1Lavs3PwQ3F+vB5KK/+XtYP9qfK9+K9eMVcQM850oXPhujy5tOHS776sJayrPYh/eKxTiltBO5XFoyE0wbOMTsfYzB/D+DR8IRgZIVoy9aNXNgxaCFUZ7G66CNZWR4FLhBLh77FNIrvcvG7FIV0sbsRKxtXNKZRqUWBhvTgb66dOnK5nMcyKynOZgqtVq9bmD3MJxf27o7fGF9YgAN185pgB+ScbErsN3+0bXEe2Ydd7FM4/lvNWjeBg4l8rcg3hujtlJKwPLCQkCS7kZGiYsLLCE+Vm0CqcucLwvHrGlOd+XjqWOTH0UOg/s8jlNkRx3NWDQXALaALqt1oDmrZiM1rZp19G0G0s2SxPWee1G8cAYY2m2upT9Dm/AHeoOh0NDKkp0yrASrHGbJcSt+0uF3ObKc3kdTa5bGs+ahA6yF5QKmdEqmtoUY8FcR5Fj923kz0PH2O0y1vWn1h/mplVr5iv529IKulw/pZHg9S1/i6ZByftRGSHl8LFUK8u3kcOi1vUc28OJoD/sK3ksCWP7u7TBurYt5iuOWXVig/I2/mcMpsJrVI70VAGoKSArWTa72PaYnW/KcIJz7Cu6EteczU99gWVeKqVB8ze0IYCYNpET5JDjL8HtGwtKxQpm5pak0sZ5k3LKOxyO6aFrhFXf54yBbetpDbxxX8zqI9Eml0M7L2YdQi0jxQsEmo33HG+4cOHC8cbVqvrNi6jzwRQbLB3eKUcMMqqsEMcWW8y7ZAwxmuvznC7X2qfnNxb6Gs3P6Tn1Xdddm69kyoMVkht7d9IRrjo0OSx/BxG+TnKecj4ODg7qHA865tFHH6320fYgJtOVZa1khK0VxhXL+0BPPapPmxpHO7velOAC0jF3OHnY1+JPXyQjy5Sy0DIJoZYQM/0HRU7L71ZOCJZr1RmPs85Z8eqAml8iN+oqgBaSOMPUWNy01S+c8MbFrtp/qs95rv1PixDtWo61PfcampkL3QdIGJamY5Udq19KA1rJA2MkoKlgODU7loP78AZjjOwYD/48tsdS2nAs5/lS2k8z9Wv7YuentuWYuZBw8DypdUliszhhXfcLqxgLyQWkVC2lbJq4YlEADsfckSvUuviP+i5zzpjCvQ5RhxwrjTV4R2wjV7VzpbUpJw2j9qNYFymT63+kGdQyT2ls5ohj380hju0xBLGNhb7rNlR0KMpAOSi36pErH6020Hwlufem+Upi5zYYAg9EtWZbc1Muu/ZRbt/o6xpLFNBD3lPXyDMnwt1gSaTUN7RIqJg2kePk1s4LkcF6MEgpRj45uSO1n1xTV5iNOZw3Vjl0iOdcVDNxDWFrnRqcPIaHE8fukDsC3jVo4IufbdF2UKJFoGomLCvqqY2ZK8dRnvKboLKQQm3COjo6OuQKcJ4Hxf5yjDD9pThg2sbb6S9GAughu5sVivlc2sLJY9zrubB2IKbaJzZJJG+wGzJSGbRzY/6OAhKxcxzlsX05shPrwXJcKgphnetHoJxA+i6Tx2VOCO2/ePHi5RsLSuVUiO14XSMIUlFaDsc+IfUejfFupK457/c1z7SkIVdYa9qEZm0p13kn/Hdbbcnyn2AIcM65WIbmE1+1YdbNY2zNovG7SB/j4bw2vF3y0LWd+sxO7uqz6bO8bTEmedhl9/GMylpmaZeJCVDL/JSDWFSTZsUxax+5tiQprCvKWW0Qj6SnuS+06600G5zl89hkIj2RZeM8WOrWPM6jsUaFE9XusW2bL+mZ9XUvmyPlE+LoAhTywZB5jDaDYZS5Oc5t3B4MOZoTRRUMUkmdt953YaVdxFK1LLthjgre5TyHC/UlY5cj/dyy5m26OhIfhqVV5Jfa1kdx0kY6KcTM+Bb5aD4ZrR7audq1LAc/f5froDMUTX3tETEuvhkTfLKoeoyBsSzt5t0BPhymWl8nw2ljzOeTd+2jSOpaU7iREnJ01C5qyqpHU9bxfvpdwl88b7Mceb3cCCmrrvF66ttiob/yw1pc6rnU07mXSvwv2tU0cxcfl6v+7KOvwwXnNNGH01KizXOeWp+YTx89Uvwh3Z4hiSgppqxB8SZ5yO9SVpbB0jqCQRTbWGFKmHIkFgZs1ceS41ZYL5RzofaBxGxo9f4iNNgJj09VMHW8wyHhxLssdH+eFkFoZNIOq1VRkUjKopLyoQwt0mJO8xDRYqwBe2rQzzJeynDaBtc5WK1Wq3NsluL8Dj7oQFi46PvBqYM6NyTnZi07X5dIBsew8OcQx67bZ5fXm65/JEYQ/WiObOaKE0Cb++pmYUn5LtpqLzEXQgn5J2i+YiWBP5wfqGFlCXMp6HlhKf6rIZbzIf0eeOMevusYA30vLDSGw3uX1xqHPMZBU5b1e18xa03usbFILe1czcKESgAO7C2f0IYJCyuMIV1cML9waHfTLoAOolg4WVp1HBdObo6+0Vef8r7ZN9DH0bZ9x5VjltCPpUq0ieZSjjtYyR1IDFiIXIY2KGoUhpfF1DIrAsERfWCDwAXR/DBFLSWFXb/r5N9ojy7E0R05bZIKUMoNYNKO1bZZz5vlv8QKT8oprLGeebATETVGzE1ucewGUyWPtvUa8j7mKKxzypzuwGE889WukfMMtMF4B3NT41hE177QSCTUzE3S887f+W/1CZvOHC3sd46j3CnUeR8F45TIY+7Ytm2m2rb7NgBN5YporgAkntizjLka2H2hzoVVQv6HZp5ib3x9UiQKC89HYoqd07zBcTuu26n7w5zJw59fGt5G04Pmq7bcCpYGw4itVrjCEzEWWAp/Gc5lMVtMnUo5Zk6uXayrNuYoY/trL3X0F3qM3hkDfUdgtUGsPVxLnyby7zH+bHO1gawrGb5kK3gJfdMYFBWrT+x9ISl94dFHHw2Hh4fVgZdcckm1g0J2z58/nzUnipYBad0Q/z4qLoSj1cVwMRTV56i8NJTlY0aPZGBsqyEv+cUaijz2YiS77le5US8a5kzec0Q7c5meCiG3hR5McFawkiZ3NSc7mqXoGM4D5GNOnz5d5f8xD5ACQeuA0D7afurUqYc3ViSUiJmqpJ+DkeO0KWDalFUoqk91E9EIiFL8lR+HYz5gn2G5EBNt/5iGA10bFLc5J9RTpTRDaLuUK5EjY3HAn3IfpBzrsXpuMIRkIJwPBQkDtYqgMKBp6iovhFV5gXSP6nOq+suJihZB7KLTz5ucfHQ6DxQh7wVH9PHclvLsh3aka35cza8r5aDVtJpD2/JJSGimqphgjxFCrF6anNac6nhN0kDOxSqOF4uxlSQP7eLNbSiky1oTUUo3tqf2tQGqmj0Vu0PsG3nM/T5WoTnYSmHX97v79p1e+G5OaGxT4EpLiR0VhZYYyw+RlqP68al7ihET3lfEuf7ogbrn5IDG7yP1AacZT7P7FRVhEC5W6nxRFpUx66hY+0ha+UI2H9bm/txy5oldCaG5C+0xHeiIsjjRRNyB3g05o/hty4/9xmNO6mNP7RQiA+62GkQOLJOWRWa516dzTCeH1nAk5LEA2VAxFkU1iC9ckUejsY/PX1UE08aUhL6R8UxRbmZoj300qeXYmLcteyj0Zb9nHMuH+CStYyPH/xAaGsLJb8vUn1Meo3n9/IiuWJnavphfG+/DdKJr0VQaU1l+Ea0seRxpM2V57P8oy/Nr/8d5PsO84ebNZB3WEeMJNPdP7AfwfeoL2wgUxyZwpK6ZejYF7YkZXJOlKDNTPuNmPzn2tcTMTxZS10n1jxImxDVn480tXIsx1i4YGsxcHGd5VD+PjqMVal1G2hBTjZE8ZHZw8tgf5DpS9wPloANCssZ3mxvrGJoZnmENmqUGIo/FbZqMTEVSWdGtKcR8KhZivu+DsiwfS74Oivmlv1rFY2uApOxrGuMdhzGSDbgIB2u1lUs/jsMq1wbiY1OXZbXmyw7z/vkobVfYZwG63+TB9759TkSqHY9dX93NbpoDPCjCF0foFuGkfA62UD9xG+T4Z6x7og/lclDuB+d4kIyn75TrQd/PnTuOr+J9dCxdg3IF13mCV6yE3agumG+Okwg5I92yAcb8Hjh/llzpqvaDlJVBq/mAR5TfY73UUxcmU6pfl7pMyYEukXMvfbf9tMxYw/Yr1Dzod642YmsXTXMURjahZcfyJWzuk3KwVLa101g1C5P0yVhmuRA2tSQGKxoBvVaaKQo1Cu27bF9JQIURL12xWTg8/lTKxqlqf/fXu78OaEVQ7DuGIg8336SFeVeB0VeZfWEM0iKioFUHkTR4WxvEzE5ohYn91s5fb5VHNP4eP660z6PNYESroyXnLW1ndXR09MRSzI2S49jbNFnpjdfwecgZfJWwt+mIkfmRxxQjbobEnEknx4m5ZDTlima66T8Si4niWA4VrckjJ/oqNxjC9qWkAh+ax8X8zVKjSPlftgXlgZwvYIlDrgRvkz4QVNVyPPbacUfFwbHGUV6s+tGq9n+EumPlayTTEfo+oj7GEtqhz9H8NiPGMbDEflybXVqSh2aFwX0MjVisepwMptu29XEUVhsfCMrivp4vye3TeCFsNLkmSMp7jxXTZn1s2M/WCgxtWq0TCKul9LHoAj4DYMx3pusDdcLKR2xut10i5UCdQv3mhq7tmCKTmJDGiCn0gXAzxk1a3draul904lvn5chubZ+0VoW1BlJBmrCswtFHgg0YIqqVvA4dc5FUVXHYqjh2ozfIYYfvlvs+lo2hHOjbEv8chfWu6szmLAqyGRJs1krXJx2Cy/ItwIC0z5H/cRFHon3SA5Icgu1Cwo0orACaAr90UovACgdg4iBIRPsE6IAYAXAEf+27bX2vJvoiD9cGjrFP5qtc7ELT6Ec4xcvo4xqptpB+kCrZeAC/SFekiL8pF1Nmpq7ah20JipnMYtutSCztGvLcyoRFcb20JgjlglAMcLmOEeYTeR546QtprIturH4VjcSiHI9VGY4OQihPhXD+oAxHl6wjAVq/bF1Hgczm42oe+0o8u7rvttrHlCOZLMytD50IJD0HgkhjyuQRC4ONObdP9vejuWo+6Zy+wMdxDggvFlis1/qoo6zW8p55gY6j9UHWro0LyaeD2gXawKI3CfO1mP6Tch1lIIplIhlKeXVlYRhMTfgORR6O7XEiAvTR7TbkEfMDaGgb0ovCOsfRnhPhmgKWUUBOh7yOVh/7/k/MYdb9qucFg83wxDbRBvUNKUkv+Ls4avSkxnEl5Jj0haWMHHdxH0NcYx9NXG1MC/sDdHjGUgfakUnKJNMH0IgpdGgAACAASURBVGQfMoirD1Pm8fXscjWCyS1XlqEBt9Nkiue1/AxZkVTkVYBG1I7D/fV34XAqVptO+T77QBuTlWaeSx3fBVOMwnEMj6mSRxthM0zf7UfA4u+curbJUJeIjfZzTFxdELudnHvFOuDigbmE1FgPRDMzoY0tQDgk2gNxu6W5rEj5KY/CxUb0QNlomfrcsv5HgR1HLV3jKUf5LpyHS4e3Uf+YmgaI5pG+Iov6gBYVOnZdUyauPq+TYyKzLEoSmjKAuYCM2oSVspnJikm2wvAxrcFOtm1UtVF+mRHloJ9vNEY5HUe5ox/MkaTm6+DW9/Vhy++OlClrFVarU+u6rkaua1jXw558sc9rWOUjGaSItE1/rZ9GbqcJhsMlZuqxIy6KY6XjqGwuViVHDVxkKT7VeUYiTcNU5dgV5uqPGbr8JbSLdq1hBbIiJ6oPT8S6Wn+XnxACzN3N+SN917WL+W4XJBISfSHXypKjwTBWuEFjKM1ZhBey/ChmZTZYkbvJyfHNsYZwsinWqFp7iZq7poldjY76cPyOhS51mfPsu3PCtlFFxh7Tsa433wmJxBIP+6prrlaDxNHXs7eK0eqkRWfhcXKuwuZ17EjasHaiP0JxvZdeemk4e/ZsFecb1i8fxwPTfrqA3IcVw4+MLdamkKApsGgqXlq2lkojheLoImsxxVrzKGpSqE1bfF2YC6YQ/84Ju4gWcfSL3Oflz7VfoGzUNYHhBg3kYN/GJHZy3rBO9BDpeznmK/rwOiF4Hu8jbjh16tRDKy1KIIRN7QKz0S2bWymy2DXHVVnnkbAZrN5Tl1dEHF6FETNer2conOVLftFdOE0fU42wyx05jwmtf58EbsY0gVWGn6QbeLqTNm0zlvM+dk2r/inZrh2z4QPhuVw2DhSLiKQc7dKBbmWsn+LLl0VYkTZRbvpVtIgw/brdBeqYgngM27VjPu24T88MZYtlikFzjC4Md2e6bB8yuzs/niUzuwysrXNWARpBLmuLRBBMtfGkwgwkjgCdhD6rUARcl3Yjmits2hBlOVgf63uqgXaNqQuiNuc4OfWPodu0by1kW99CbhRR3jWnM/3J0JpczHJkXV/bhutBpcqqA6piFUPTllZADDFb4XEkxdogRd/XhxWy8uXmyARvqBRzbwWFpJaIOd/X0GTGmOoUJnN7drkCcNv7QhLBQa0VpGPXcyokgmGkPZas5N5p37Xz8HgsM/e5b7SyluOhXVgKb63i9NDlOiKyvP+fvbfplW7JzgJj5z33vV9VuMouWbahwRLGYGxAWAYJGVMwQiCQzMR/oUcwQELiB/SEUU961KOeM+pJj5g0/6DVDFoMkJDwN1CFy1W36n3vPbsVeXLlWfnk86xYEXvvzDzn5Hp13szcO3bEihUr1mdE7OdrJPdyWNprtGZa0J5hyfyauB9Ncl0KXpP38Rpgq/5ivXdPrQ3KAm6Fz9eCzLHu/TBS50yUzrm3oXgsk7/wRjfK6mzo6+QsLFbxsWDjpVJniLsjh20V1qkVcVi0W38/zierqpTbhaEsr4hU2dc0aS/hVb0Gel17+e5r9n4RMAKwRn3smpZNfXSOxmUb5dFLF+ap+GvPigUN95bn0PLeVLSJXTtJorPcQiEK5aRLjQO7pnLqcp6XdZ2fXC4EJiDrFF6zg9aYMrtlT2Rr6BVid+XxtiA7N/oTxWPAQtH+NxdwPP95W5DBqz/EFeWOIu9XGTjogbTqqPAwz/Pn9T0gP/7xj/d7Qeq571aZX4prSgbPRMEO4EuoFLzbfbl//qOvD3V9/dRG/cmYiCk11j4jBoN7OGEdeEvJ9mze760BhlKYodcD2cTvrYeq8zDIM9NX5fg+8LNjnSBKc4z67PZf67uYbH9f/atyv+7tqH9ezs+HfR+WGqh/796929//8OHDt3dMSKvPI97C80ALQjHQ8/WDlyI0tFdcLRwLsVru8PKhRwi9Fu/j0kpo6QoqZqmO9CHCYyZbAcqLUdgb42jpAtMlIJvnw6s1nuB0P19xcpstSirEgD+OwQRJdGXVW+XmkSAC6BWwDiCyT5eeDlD8euIvpcfOsfbYewJuOXl593zucEuwJIzFlAeLBIwqKCZL+urKrMS6xGqtNQxaJjcej95HlaRPaQP3BDWo7U2PXEGclwcs/HjPT0eZvMeb88wFukqks0YQIdRgNmyTOwINFRjDA5WViuUxa+Ulw1sI/9zhZdGJ5UGZwTcSaspGM/L1RopiN5xAb41XfL837zHD33Of9vvlDt+O1+iCg8fD64JzC4+YkeCuf3rEgGmrKEGjkiyTWK99phR2pTzW86/2r619is89Tvu3hMhQ1HMdT3/mfahcicLlLszWgy3DhfdxuhxkxpHJhgJyAldcjioP1jaLjOTAn9brFYl93y70OcGCoSfoT5jTuu2//aswZlmv4fBE1t1BiWjlzIx2RfMduxFZ9wWEcxEDrsJIz3WXp53oQBC3C4UqEmyKWToYMnuLguhSfb4L+bcFaAgasHlXBg0MjMdH0Oa/dUJU3mjuybWd47fefNkfQzufXDiRj6epABuLx0MYK7dSVUWDDI5vJIwGP7Ii1D2VTznemw4d3Pe7eiHz8/qBY7sOYcGsKmdzh+0hqzxGlMxrU4CvUdFGliuD1n2EyED1bfbDqVJ50gdWTxu/3n4sB9XW7lkunotJquCn6aOzexGoHJdd32UEsP1mmvcMyXIu2A3OiC46a/Qw5YJJKJWrYe2weOy14JaFSC9ur0Egrt2HpfW9ZJqu6elH9by0HBFc2aqhp89DTEuRKHIC8HeUgvCw++ijj370/v378tlnn+33gkxuxVWNZ9Z1wRXqmmEmsP2hifuTfAtXQpgUe9y/EGQfjdtvJKxp9cfDWwaZ0vC0V2Gr8zDZPYG+BfTgc6tjcA+9rQ+tcEgWWiGVa4zdaB5n02gIRmfmp/90k/PxZVu4t8PGrl6n728C+Xr4/OrsjYR+k2BkyaO3wjwZJcSf76NHM7tAlr/6/CVK5DFc7oLiDmvALfPRtUO2mdVSWVBJ3bKhUD6Vl+18QA9sxTd7XE7iVc+oYx7k8O1k4dFZMtwtfphhLwh6JL5P8jBFRiyWG/Ed8qGl0rBI5t3uKWFevZ26Gqt6IGRPB8MB21EMt5ZFtAbcFdnLhfvYadjKI/BJa76Y5vJjckt8cIrLfLSyUXk8j4/Jwvh1v0xx4Bj737vHx8d3Jxpld75GuBAtVIiSUcv2oiT8c48fh7fbKMZqKZo7bAuj9B55bqtd6HeeieES9FGLdNaCc9Z5KYtwHOIHlL1jcp7TnuWqNL9JHEEtqpqm6cc7ZqUrRcAqzqzEoDmJ+XHvhez/au5j+qjMG+wKzfRja7i0EHrpydheuB+guA7c6jxh3sjLgecQ0jgc16cy6jxdn8/vn9PK7p8fZ3IsQZZjR+kAKrFxlROruBy13UE5OAIpRpwwZieQ7gXPXCxX89YE6i22kYFLKY+tQi53WAemYBPw2x2D8w2J0/6V4Lb46ukgrJgE83EfSAF57BPnE2wcxPCVh7Od6GdNkoefFYY7uqDESeszLbbfSPj4vFx3vyN9HFRehnX6Dnx8M3AXlOdwp8k6wELRWdre9hishRvxMGzrxOH7SekzuaeX+CpDjC2O8nBUIH6vR0vgmsJ46sBzQyp3ojTY/vpKm4RY7uOlw9b9uAu+y8Cdzn2gVnSWjWjJlq0+A9lS0IBtxxvwOSTIny7pJbxPOM308NnzcjqXjH17ULHFkz0bB6XC4mHRvg+F2FNdn+x/7w4+yEcWl4NnjvXeJ+GLgrvQfILXSIe1w8K4apOtvMKQyq1GFc7pMk6nmM713sNTmcd40/YTXe3X0/67ur+v7u2b3L6/clCmtkfEPmvZ+t3qqs/Vd0c9PDz84JhENwSiVVgMsQiYEmHLfVt13IXRHe7wekEt5FFC8eWEpJfvieEwuWW5ceJb0cpv11C5JracF3HboWegQliY2IrWZKuBZtZEm1jrwLWU0F355eC++uoOHtTKKyVr1ofz/EE/rKnopqLCaWiQK+XhacXCdv4a8wJPsDnogJMciEIk6zHYSqysZ4JIygR8WNsdGG3vEPPeHW4PMJRVErIkMkqXw61InkROOrFijd338yEyyFgk6PHx8bMdVoJaqJTzuKPKl6hX07Lyasnt0iG7J9C3q/8ufF83XHN8Ub60VnNGz0f7Fpbg169Qlrbfn8A/aT1IRUQnjrDrira7rMLGeJhGNJcribTl04KCtyusRhl/SwHQU/clBNE9fPV6gPEL80Iw5M3CWT052u3huu1HchdDWPPhjbP+NwOMTu3mua1tCnlQI6qPM+mFZfr3ZcItWvn35cR32BLY6isFLMzFrhmsz1u3K5Eyi58ieowYZafnULrlXEypqCW/CK2M/luBu2C8Qw+8lNVFW/H1aBwfQ1+txPsKmG78TKZsTsYq5wCVxeReR8yeVYsX6hMPtra3rvm1m9PhbHj/XhBMtM+HPSI4cGzwWGK+5Sb1wlsW2C+175dcfXVX6C8PIqvaQ0/i/bJguLR4z3aJP5+eO8qvGUXiD080uW4rcKseqJ9V5vtcddUHpgcOuuHTug/kK18J2weCIalsnHF2+z7QRWUuaKbOqK073Gm1Jrw1Ot2iB8RWZ6rVRL2J98vBk3KYjwdvTCd/T9fPZWUM7WhQpt+ttloK/GwfCDbM8hmlMWDYAf+5RXjrLeYN7vD64LXzTLZ/LLeRfW7bZb0nrZ1dUcJW5Wjw+sgCACY7e8N3vXkjX363+2h3VjrbaDbxlYXewV6z7VuAl7766pbhrtCvC1n6o8D111vlbxGe92icC3alNDC0xPutV8bGz+mkeouO/m215SkM9mk9iuqDL+TjyypfcbZ3YwUtv23S67JwF1Z3uEM/zGRvmEG0X+FaISo/zdtz/tTLmMjeOpYnZnXP7uBd5fX07u8oHV7biQeCDauNhBkYXf0QdTh65g53Olwb1qL/Wx9HXJxjSd1bed+LbivesqYMb1QeTBFymWiK6LlM7rkSlsmGrbDcyVEmDJFoTwj+jjoSuUy5pNHLgLsgyPf/kiuwrgFvnReWwqh3cR150rb4MzkO5X09J99Pw1+oeDP1eXx6jHxW30MBra8e9N5Jyw1iq7Y0YU5f3L52OOylwFsTNreuPLYaj95JPlrnNeq4JrSs+ctAbskuCmNcfXVu7U9hyKoIj6J1DeWuCpkZsPemV43w3vZ62KdV9tVXX51pTfxj109fj8hfl8g02i0uI+yBSyfBX+qkv7Ty6G3v0nS95jheIgm9tVfam3jfHvQZGq2VriqRjnJYRYGwHQWT2/th5W3/h9VX5b/f1mHvCKm/P/nkk1r2xw9RZzDr3ms9tbyOO9zh1uAedloXeunJzmhiMBIOuk5Yi8tMpjSwTDnifGp0q2Q7fs8kzBle9t0bbUphnSXRKRmCtdUZC0a5lamOT+TaHW7Wa7m1cdqyv3dlsx608qURzO5EjNHE+ygszdOwhUe+/9PJ2wS5DMZcdUvWIqjURaZfu8fHx3esc8WFDVoxskiDqvsFNKhK4E+mfVd7Mf3bhUuEKt6KUM0YTQzWjs/fCr1ncZTRSD0qnBMBCtAeyCicVjJa358KC2mpfuJ3VCYFPIVe+jAZnqUX0vbh4eF79A3rR/fkkA9RSR6GWBaR3g74N4XcvZE73OG2IatIWP6Cxfwz0Ou5LIGlC39UgltFa5A2Ko/MAGnMlA96PgxfMqYPZwqk5fqwBE7ruZbWyw74rvQrqzu8XbjzSQy3QB8lLDNyiAEK160gK7yht7T/vo8oqHtyzC2v19fp/1RbGS+HeiDYOLpWUeVM06EHMwrzlHNR7x7K5eHWhPUIPpfqA07ka8AtK9fRcBjmAtj9LSFX/0Q3HrI8BsuPPLdxvgekV+kiH/YoxUOZr84UiEeErftVSRyF5Ol1vR8kA8zdUnC3PpfDS6XhrVjWmXujIZBbg15liGPElOqt0WUUH86PPDdSpHybT87TmufzfXQKX6aI2vgRjM/beHiY5/lb7969K+/fvy+ffvrpfu1vPfPd/vyD9n6QEy9k4u9C9xbEqfcyPmGQYBmteym4ZLu3bF3foQ3R4pFbh4iPer0F/9xILvWlQHuMMYQX043RqMVLyHP27g/7Y2cgsqiTXat6oumB+GsqNMWUh0eExd6w7iyo5BHmVi4dGrgL5zv0wFj8/HUBygYPzAvZkla492Rt0GGo2DuZyTtE0OPwny3FwmQ75kMYBPg+nJyFhYggo6ujTBSozP9SYER4C57HJeGuFC8Lb1WZqHg/g1sPTWaeQVnVUiY9xnArjIWgaN5D513UCHY82pmICKC2i7RbxDyZDr6WOHIWXnJfR4TAJTaG9XrCd1hGEyZr3trimFaSm4FSOC0FzJ7zNGe4KIXm4CmEpTwFtXKqtaIKmaHFXKq88oQid+2S8FIEydLJ/ZLgLQn31zBOa+VUbhkyC5Gwv5lQV2SgR+WZ/Iy8pEKcDPvcoRaK3CB8X7rSXtmBzzAP05KR4rrDMthy0t6qQHiJ3scSPEafXZNOPpEblRkJa90an2VDdEtCXdhOS6GoFVpR/ez5HV5UlUWJ8NaKikxyJnN/IquwChDupVktt4TvJQTLHV4mZKMIrShBcUIrspKzCw38aRmZtqN61oBI1o0auJFn4q+PLM5gOShVP4Md3owa92djRQhFHW0931NOrSh4KfAaBO9rUIBbwFtTqiw6EM1FVl4JsawXkm37GjDCDxjqYsa5v57JafREb9BQZ/drCOtHtvfjw4cPMq42Hd7zgfmPyIX0zGCWQv38+OOP9+3V8+X9kfFVQdW9JvVP5UV8OI2VufRpnKNwKQHz0kNSL+kNhAa3HKrbAjcv2LLhZgMMu0Qh9LXbRthyOW+0GsqgdU+FuDIhMpSfqIAK0LnqgkqPuj+w3q+yGqM/X3311Td3/q2EraROIVqRPaMS4ta492RQISlApYVusMfnngt5e3AJof0WvAqcWz3RAuYBsIU5JRBkmWPZWR2q7WuDyj1gX1pykBntqFBaOZQovMZoinS0nJVXtGcqF98e6BHOHnscuVSKCFHnWd3GaEikiv/WG4PKGxEma8JLp9dbHu9M35mAUoJO1Y1CK5s7jdq+BmA+pkU39tmSfwhMvkZtq1yTyoP4CJSHfQhLEZuFjfy9SFu2Elu+o7itPttxpozuHsgdeuAlKoZbxFl5LT24joag1mg7C1vXmYnERNdbikulHBAHe72tfTKl+PXj19+qGuHjCEml7SKtz9xJRPZxfjwR/JESwE7frf87rAF35XEOPcYXztmSeJ6FdJRhGYV0RtqOwKIra0Ywsviwfrbk3ygfqBxTFtcT2sxP+Y8PvuJKSEXAVgjLu1i1DiyPOQv/lsGIYC2XNXL73jK8dHpsmUC/Ndq8tLGaxYoghIwlzGLw/t7abSN4med5jsmwpdDqJwtTZWiSBVY3k7fmfRwOTTzD0eABK8E4VyaO6ctObkWAHwDmbRTCDJH2988ZnljXS5iIS3F8icLmJdf/0mFN+kxwpJG/jt9bRmEUqViz7ai+uuIT4RKrsQxQ/kV4M3q1nmHt9zyDHhka7yf7QKLEjRfuqrwfPCtry20N/LNK07YSSf6P4fSaBdZdeVwe7grqFCa3lLNFG2VxX7Lt6L4JyK2X/6vcw6j8i+pu5VRQHqvck391h8lxrO/BvtS9GVUb1/0ZtXD9Xj8tiVJdGdufUdySLkWY4/cappo1cZCI/niDiOmUJfKaw1k9fbqF/r+WMYhi8bcELWGxBV1KRxgpS8eMhbxmCKs4ryMTpme4tvqFXo1/Tgn0rBeFzyGwNjxOVa5XOW/fqw4wOtj+D5PL9X79XfXFtJue3wcyu+WxDAFEOrICTmKa5RxxRgD1G/FTsOVEWRPu1mweLrEc+7VDL79lBXzPPVVezdlsGCdzb8l8i/ahZD0rFX1h91X5EigBVU90PcIpauOsjvlwmKJ/gE1alaVX17MME4XO2LN34ft2YMuQwp2PxiFjyEXCDa3rHsNv5PDFXsMyY7QouRcB8yxa8i/y3rL5paw3N7l9HiwkpnDcoebxca+sd4CNIYG8t8KI0Ksc7gLg+nArY3BrvDCCT/aZNfvq52NWUUcRhyKs2KiuTMx/i7Yz0Gu8ZKIjW8g/Jm99nT0ekvXZy2t8B5T/++ijj76/wwZwsyBD+LFo4nqiMAWkvJCMJzNitawNd+W1PfQItFuCa+MzYhkXEBgZQHmQCX+wckqgMlCyqDf0koGtPN+15R8qj0w4LDPOTBH55/z9s9N4WeP4fXd+Agrt8Hl9uR2jzHO5BbgmHm9Fcd2i8rgbDafg52UU3sbfPQalujbSdg9svRJrTfk3mitSysqvmG3hauV2M6wi8ARUriVqIuywhpwHgQrrFhLkdyHyDHda3DZsNV+YPJiTByAyyArUtdq+Bt962ZiNoIzIP/Q2RhYoFCLTC5HrthKr+MMUjxrFrfdtKYbIpUIkjvUR/Hs0aYvRbhnugvcOS2BNxbCWYYa5jKyAGhWoKv5/K4YmggrXeVgq/1ioS4W/IvA5EJW3xroeWH2HBMl+74c9bPtD2D6Nc6bIrSrAaxnmUqG1O9wWjCjLl5r7eEuAwgmNx8j6xZi9guy87m372tAj/7Ac+x0p4ExOpcr3ya2+sj1/9R0guEHbgztg8cODKuSRQ01/hiDojL2jMeVXF7B4pteGvXCLAubWhd5dKHO404UDUwZKkE8rHkGC9bfaLlcew1H5x5QJe6b3nlJIk3vpH+LE3kR78Ew+fvAXWMcxR0KRqhpkenbTer2EjAbN51n6l8W14NpC5C0IsUt5Hz3Pb1X2ErD2HEDw9UdWMl7rEaiqjt62LwGt8FSvx9WSf1E/lfeh5DKjIcp/BWc5kAhsktsyXoyPqVgl/mbEZOWzCbbMvTusAy+VxlEMeknZspAmL5lnR/IOmWeyRufaymJ0BZYaw57rGaM4CnsVMPpbORCrz/+xci3cdix0pDTi8YDEsjvRTEyJtDRkNskzl/xkvudE7sBgS68ja1EvbeulQ6/hN5IEXgKXfPd+l/xrGNAqDDga+WHXlT6oOZAdWvnstYWRRmPIRjmVVmzvrM353BshsbiwrrcGr5UeW/dri/qzieNrwCXwmd1BfAp6BOqtQdY46JV/ig5M1vZEalpyPKtULAeym4gb04IWosgQ2TAXEkUhj229Zs/jUpP8GuVeMoz0cSmfvuTwIcKoQL0lyArpGbZERHTB8ow2TAmgHFQ5MCvjE+Y+ga7CZErxnGwpz7hHqsPPn6fJnigJ00r2zOXc84g8jq0syFuoYytYW3lcG8+1nlurzpds3GTnXfS8+t4jUJe0dQ3APikjN5J/2SR5lA+JFlL459gBki0a2v2Hx8fHj+seDzsTvq4Nfvfu3VlDsztYi2Xpn3+XgvtAvCKJGOeMcEEfoqOWsf63BFvE+7eekJeMP18bIoPKILIcbwH/kXLRyilfZg3cMm1dEkblX4ZXFLRy0R8+fNjXX5VH/V7hk08+2X/W+Vj1QH3nh70PxOPj9gg+nG0k9J3AzrLNJVHyx9cTdWiESPeE+euAt6I8mOCILET1fE97Uf2XttJZ3nItQY/yCOv07zy/BozKv2hFVE+6gclhxR8RXzAvryqQj9ng+k5YY2pzX0tTMqRbBBhhKCTQW4Nb6PMthRG38MZGgFmbS6zLFqxVb4+Ca0GPQdlbL/vt5cxaymN0zEbkn1KwrbB/q21/nSmRKN/CQmcPUd6DdYRNAKVVlcZT9zJ4RLBWPPVW4C0qwWvA1soj8gLWViKqvS0VVi+MCNReQHm1Rd0jz/TKv6hMjzeyJBQW0fJMNUdJF6/JlaXPvBembFQiKOpIFta0mu7wMmGrsRsNJbFntxDot+KFM4HIQiCtUBuWvxYs8YKtj5NY5bREuLN61qBV1murIax3/gIi5JVAIUqh5TksmSTRs28p8boF3JXj5UHFnLcMZV2yvQgPxGdNObE1LJkr2VBV63pUjyobeSit3EeVrzVZ3oKqZt6ritB78AhmkMpAJomjrkV/d1gH7rR8hhFaKMvb318TLt1eLyjZEUEv3ZlxueQd+5H3ED0zAln514M3q6elZLIeyM57IJlcBCISIaGeiwhidfiNLrjpxXtB6u+twUtMoL8UL3Ie2APhn40sb1Z+CfS29xrgeEbf4ZMJv3rNX+/lvSU84OsoSfnXE5pCJdGTAxsJpbk2vtofZWJrgeu6X4N6ra71LYfz3+t3c2vweN8occeQzSDqCcG+G0OovzvcNrzVEOSlFf0tG1NrCeTjGX1k3itvpFdGjHhOrI6yQKlnPZ+WolDgx8Nkfd0jWL/XfYJWd/1+OPLqYRd5GEoLMuKPIp1Jxm+5omJrWGK5blH2FuA1Kw/vEbP3KERCZDQEnGkvej6CLT2YNQQyCy/5et3Lj04iGrfCg9eQf1lPphBdgM/usCBDvLWKJNuxjOsWtRmt1nhNYau3pCi3gFvBBRegbI1X1F4rFr4VPluDkg+RMCzEW7lE1OJS8q9VZmoszS0HxTvDQZgzLpya9nTbvVfa2z/oG7cX2Wc65pEf9Ugycbq3EOtdC9YWZD31bW35vVRD4pJ44xy7NM3WnKtKMfpr6PVhzmQrQNy2kH9RtChTprW6yyuNM4XyOH+6Y5ors+oKlUZLiWRc6S1d/ZcCvX3bsvxLTMy/xPrX7GPGkDPwc2wrOl9q/s5k/wszgAvkTJaszFqz/Kj8y9BXKZRMvRj+MwUy23HuhWjHKEYWIZ9F1N/3g50NiW29kuVacFcel8VhC+G+RrJ1zfZULBvv36oHvwb92bVoxdalYCv5FwHzhFh73uPwv/HY95Mkeqtia9wTPYrxolLK5lCWWkS3Mhm2FNhbCtet8O6x9l6C53ENJTsiUP2z/k/VeSsGWA8e7lzlpgAAIABJREFUmVCMF4jlwos5riX/UD63ZHIL6gqs4zOTeB8Iuk+R9YIrIDKdwuvs3j2ncYdrw6XDT1kYaTM7TzP3bxGUEuzp95awpfzLeiwqYqQUlsqdHH/PT0eZ0If8VnZ7V4h9j5BqAcbSFEHQpcuE2O5wWXjLuSi04C+xuOO0zVp3vr0l+clrwFJPKxMOWhq+WuIpRDzDcjhM/jFDv5VWMKj7O96/f7+/b7J9dnvsTM6b11Y/D+8A2V+vz+92uw/0fSA4OZS7a2WfkJyffJoAWgqDfTfA5WTRANwC3JXcKbymvR+RtVZWth51ubkcIwmJeYXlmAHILM6XwsfeMFX3SmPT4dbQK/88/hl5l+E7q8fTSeVA8DlS5quTfSDIVIzJtKbXE0vlUlidalWBdKNI2TXgtSmAt6DQxoXxy8ZD1ZNNyrJwz1pwab6b4KijCC5h1Cg8riX/MuEypJ99WgLd8NnvRK9nYbWYxldQAsWikFNKR3XYJ7x8J1gC8Bbh7n2cwsi5Q73lr03zWx7zEcv1JcwzDywR3er3JTYTMvnnIfJmVe55BLAd7GvkifoVa4cjTEyOP3kgKkSFjbKjEqJnjgK/8JfoF2ElLUl63ZPv4/DShMZWENFATfgt+e6pyakZIs7XF4fgXqIyRqG7Vr1LgFnxW8q/TC4ukt3MIfD3Tel4g3DnkcUw1kTOkMk0jEjs/3VaOehxzGQpXkabj8CSeu4C+LJwrRDJBKt7enkxg/dTWPgMg36ksQaC70s3vCyuH/UDY/9ZWMJjkTIYNdgyypLd9/Id93dE+PgIlE+wF/VGQvaX0WDRNXYfJ2EW1DMvdRK8RKWzFc7XzE+0JjROXGVEsd/ZNp7LNYs0nucKYs2wyBYwKlBn2ONhgP1uhanwdO+ywr4Mhm/plH+e5/AZNqYtr9j6pjwk/zyuvD3xQFxC5AyJTK4iSsootzhSRirn0cqB3IIQvnsftw1rjE80gZfWbx5Hu5qc8Gfz7yWusMoAi0p4WeH73fJC2FlZS8PpvfJP1aXkbeRRMuUQ1cv4Gp+xMg9FKAJ7B8j8nDDZ//nzY9QARQRQHZo6tvIXwQQsXsfuvTW4Zt+33H3eU34NGuDqFJx8GAbuwaEPvXzoIpqft+aFLAnnGChj2IPyQvB4E5N13sjupRkT0Bn519MeixChQkDDp8p2H/azY+/R26g0+OSTT/bf7d67d+9MNzw8YGMFJgrGfCO3/bSO/f+h9lP1ZIiWdfnukIPXSq8t+qXi2dMGy2DPYSy38hrHFw1GPCXcwlre6FUvnbKQlX/1LVt12qtERuUfayfTtrqv6vKhvYh3VL0PTGP73/Yd3ykcdfDpc3dWJw4E07RrTUS0fF96knBLuIf/xr0Zxrvqnq5vEGkCa8frl8A18PBvG/Tfo9xHZjnvqFwalX+qLnY/wqlXEbXGDMO1O8XkXjMZ4Uwo29Z3LIsEijrDYslYR+svKtfKmbwVyDJED2Sf2XKjVgaHLJ49dU0dic9c+CGFYgrWyvGsUcc15hy+9xyXnWb50Yxl5tEsgV75x4CFwiLIhi5bKQGBy493kbAvYu2v6rSGc+3NtGIv3L2KOyyFrPLwE189c+3wVU8O8azmlYT+tYw1JXi98oje/4Gb5cqKGwuZ98LkX4+xpzyL6HcLWjgWQueHKGHjEylTYg21TmK3lUWUBGLQwuXSyuUWvZwtvI8sXNv7WKuOVsyaCa4sD29F/pdoWC0xIKNnM+EpDHu12lsKo/JPCXcVXuvB1y/r9WGqVqhrxyYAdsQrmP313SnyWFbVpTSkQjiOG8fLfPd47Dg+bwW26PdLylWsARgSzeCGPMc9/B7k5nTyfCTk8hLHlMkSlGUZI4aVwT0gRRgIa+CMnz3teH7rHeuIT5ROYPnyna+kxXxHwexutSYLG9jo02tTfPsVS0KxXMexjvK2Fchry/1csz8ZPsry2ZpLdrFtZqUqA05deymAwgxlWCYExVZfKch6lkjfEfmH7URjWDqUCLZl3/3OdPUMgweVHLQt67Xiuub3448/3p8Bj0RBrdlyebAtRhxbmxx5MqZcFLym48NHYAvBsJWwuSUhxqzADE9nyq8J0RxEaEUZRiATg8/AKA5ZQefDUxFsGcJiFr4as5ZcjcY8b8A8L2+uMt1kvP+t6GbPVn2wP0xRCfIJlpqV4Kz9iAlaWrYQyyGqd8QK6IHXYLW/Ns/j0oDGjgLGo+vxZRy28pPbz1W2cuj093rEvDU+85GINV5dO7IyCQHD+peWfyyq5PFRSqJVl8HJ08q9UYiUo7I5baTlKmcSQFguutbqZBbugncduIV3ny+1hhUf43xY35Bp5zuKmzeFzscodr0Chgk6XQpUBGUNYJvr1vBCri3/fBl2XAvzLJW3czzOvZX/UJ14+n76W1lmiiC9DCg1ZJmH6ovqvEVYA9eXpiy3xpfl7ti8YIojUjTFWf1z85yrfB9ZhIDhtbaC67FOR+vqeV7lPzz0LMfFUNZa9NtC/jGenWDBRxQGw/pYna3rZ8e5swaOhffEPT/jPgstz6TnHoOp9Fsga1lQl4h7l7uXdBXwgjprFXK+ynkXGch4QCxefgvss2TOKQO1gJBmezkyhyiyI0/WmnNry7+eHIiS2a1ccqv+h6hTPFMfJ8xxos1iVQHW0bLi8HqkKS8lzC8Nve7pa+hPT7k1oDWhvZVXkjmSWuS03rksfa9HNG/i58rQc2vBWu329N+fddUCVmaJPOmRf1mF0FIUGaMiejbjhdj3B9bwBHs/7D6ej6+UREQ0dLOYB9TqwCiBIoLc4bK02lJ59LrhPVbgaBjgfGJ7JTLWxwyvP+EygefxcvleheyiMewJYeGx8EuN0SifoOSkGluFU0tJRdf9ogtVh/+Nob2dQpRNCE/caBAznd9/Tnl31ns2b1HwX7PPr0F5rFneJp3KkzDgfDsW0kJDK+7zet74GjmLtXDoDf1E4Su2BwTDlb3hJ1UW5eYa8m8UT+8UtMqpa/Q490IIWOB4Y3PNVUhLDaKV8d/Ra6mHNUbKaHLn1h9aO8GjJtN30/oxzLcIrzEktqQ8uvk9IdMtEtwq7LD2sN0KH0zJV9dW+cAOVmQQnZFVFo6VknGtUH92Yx+mG7CdVp8rnaq89QdI1nu2L6RC/W5t1H0i9Znpaa/gl5KqGGLCe4euPP0uyLxtF565Sf451LaxcoK6yulO9VuG16bcrrGB85LjzPg0wot9bz2XAd9nxKdNisvnCJd6k7PY42GAUZDegxB90j3zStsRY0XJP2YEZOUfSzdk0gEKxx7YKxRkxHNm5IQ7IUY574BZCUi46HdL2yLRImi9D+RaYZktcbg2ZJTHtfo82m4UevC/GazhYfThmi65LSIrAo4bC6P7McJ4/ciJuuzk3tGxbCmelrfQIxNZnT14s1wH1odKfTe5nZIqOTOJTTqRssHyeB8nZmStKaJHfyxGfUsC+yUojx4cr3V0zFLF0LoWzYsC/BvxbU+8+zXBVn2eYCEOE5RLlEeBE2rLAl5jio7JP8VLvd5PRmlEdah5wMrs8KKytLzrqFylVg5EPVsIkaN72bABC5O9Zsgy+FsTYiMQKZhIoXhQseqysuJ7gh7e7psHI+GaY0vBvB5pE4W6fa9xefs8zY+2Afd+YFJ9xJpXz2blH6sjkn9Z+s4kNcEiT1iXavsBK4gmDhu8yGvBhiOBrp5T5VthA/uM3vX7UiCD/9rK49o0u3T7WY9E8fNIKALrzZRZB7bnARQ4KDizRqCCkVfXKuh5pW0vZIzeMiD/1D2lXJjHrOqdg8NqsT9HSrWQm8jKgKxrNTIxRrUsm+Av2fO4hvJ4KbBlfzzvoOESGT699XtQhtw1xm1pmyr0VzaYj6OvrlWw1SttmdehQp9L5V/2HhuTjJd8dCqwUDTwZs0/lvMlZiqPkmGW1gRUOLL8jX+HiMLppcCayuO1wSX73WMx+0ne69V4yHjbUEuizOVg7twno+5HL3xiJ+62Xl2rYKtX2jIDhN2PyjD5F7WnrrHcSySvUeGx8g+FgJ8ESMRawa7sjpOqHf+dSyl8NZbKm0yH95Gw9d5qYiL4OKhSbNcSvi/RoowgO1lfEr0ZX7fyHJl7LWWQCfE84VfgFOywuJVql1gYtsIwzJJ51lpF5RVFJgyVaWft94Eoj5KNMwp3pGdP+5FcxnpNVtZ3fFgOqe4Nqfs/6r6Pd+/e7b/70Nb79+8rrT47eSMhNoSdZffbAh5ib0UrAOUtLBU8L9FKvybOPW1voTzW7PtoXYr/lWWtnh/BJxNC6Fce28IcrCJifWOAzygvA8uMego+LK/qZHKuh6d6nl9T/kWKO8ubUVjrGPFhyRXl6vgjHBQCLEZ8glTR95mWjjocwWsIYbVgi9zHW1QeLX4uwnJjgj7rYWRwQcXFyuTJtY0RpvrD6MQiEK360ctYa7m4D3lv/Upb1Tbezxrpql68rsZmZF7I8WFIM1cqQ7weLc2UTX/cN4bXqji2gteST2l5B71xeIMsr7byIK24M7vH5mUO5rTyyNCFCX6bx5nwsu8D9rsV8muFtJa8yCzjyawpT1ryrwXKS10admXlGN/ZNfpGQixkEG3tZ8DicJlJMMLICH7iqbbWYojXInh7YIuNg1t4VCM4eG8jayl7iDyUVh0YIpsP+6/8yQ7PZZu9aeKagawVm/H2s/e9UjJovdtj5NTd1iGLCL28t7X8y3ozrP6ecVX3zt6JnnWB/ORiiE+QTENkWp2LrqnQFHpKmRDWLXopb1EhrdXnXu+ixd8lmZNQdfZagK25ZEez30reoySFVeuaKmP9xhDT0hVS9Xk8cJGVaVn4GchGcMqA/FP8HIW90KtV/Noap2m/oEoghhW03HeNOE9Cso4VYcVkJhxzCW8RRsMnt1JuC7hG209CWPOh52cVdlHP4iQcCU2ouq8BLQXRMtBGhLAvM/J2wQjYHg9sa61X2mbGf1T+qVCigmwkplWPN7DkKqwCmkpV0m6wjdySQVI4XmrS9bRzq8qjF5bEmm8BelDKWNmlIybdA6eWYm/CvI/uaOBhdKEVMvbQNipzz3vABPpSD8Rww1VemVfa9vBPr7LsgYksVNA4nyobNjZ+3KKx9kaBHAU7E74WtvPip8N58FhJJvaW0aL+ml/xZd9bq8BYPT3le2FN5XFN3HrgWocmrglrO6mZsEPveJjCuES4Cr34kkhyK4GkhFPsxZz3kc1bv1pqlA/xOV+nSqSzqEoWWEi99RInxTsZOavqicayEHp/+PDhuD/Ey+EKVQccwnsPO99BRDTySvB7AQaMBHcr5qY8lK3CU7ce9vJwixa9gi1wXVrnFgJ5NEzzjNOaCI3XFc1n2pJQIpm6CxkL/50JOXbmVY8yYQckogdShaZ94qGMaxmjGfnHykSyl9XBvGIl2zGngopU9fssB4JWCN6bycZCTMq0OsCSN4wQL0lY3mEM1hzjXit3pD7Fl2wOvDToiR6osLUXUJFwVyRiOKjd5r3v+2hZ+5EHtmRMR+Rfts3IcFFhKmYYzGRVFzuFBNt8YA0qlymKubFO4aTyWk4xJXb0VuE1KbfXrqifujcToTUdLfZTS1gnJFtedzZReYqb/n0tQEMx62G1rORM/1pKBJPpSolEy3CjsWVG8hJYIv9aXmAEii+zHnPGsztLojMGOFEyRR/l4ImkwlA9bvGthpb649nrMOK1Bf3a+Y+t+/PMo0x5GBiPuyvJlVBsYhZhqSn81jsEcXldqi/KeOydqzE5DH/uASjF0fJAsAzL7agQz5ryZ1T+tbygDI7ReClPCBWzUqj0OHds8PnBx+NRJCxEFXVWxfcyne2B0eeyzHIPq10PemivYusczoUWE2DI94yXlxhAY6y1nhLKhLAiD8PLi/xYafxbwladxouGTivUhdY+5gPWgDXkn4oWKbrjPRXeyil/PhZ0Ga/2RnZnhyGiC3+4KvMkRRBpjZzH2lbDGpDt02tTTGv3Z414cRYwl4dtREpCGVGRohmH9XlGxegz+PZ6YBz/8znMhH/kfdjKKhXDZ7/Prf0G6p2wlvzDsBbzqFifmDxutef3yrBoVLGzsPBmFH4qc2yRzOL49kIYKrJmWs8yWOq9XEv5XFrYbg2X7I+eeOe5jSXtsXmi8gMGir95/f14rgHYB6Y8R4yg8/mbQxZDPVanX74bhVLZKi2/h8SH3+N+cR5g10aNxBH5p8Kr3JA/BSXfaGgKTiNWZXdTkJWv633rZ90PUg6DUb97zXTmjRR+9LUfQM8Aiul8B6bD2mnvXrLJPM96h+k1IGtRZOAtejKtyRn3dcwYYBNRxYujUNYYzpcFJRCxT1GYQ83fJdEAVNaY72Dv7mDeCC77nUUuJ+pTaQjvVgiIGRsZ+RfdQw8xSiWovnkF3Ru+t+d2u92XOzZhipssLa8ELQbWIYSsZXNGULAKzjt+m0n3pfBWw2AjMB+X60aJcwQeb2Y832sZRr+fy/V2dCzv0ROSanlXBmoux+GgPvy9clDfPSgPJbL4sVyrbM+c1OPeKf8aHoyS4/57S3l6MPoqPp6nQw4kY+UxbahiahlNiHVF7R+VWRlNbF1esK4lzLdWHreqdMbx6hFO52Vb1hsLf2Qs1vWURxsigdcTcmlB5MHw3+2xmUUOpmcFoM+BYMirp+/orWCEBKMhrTrU/QhO5F/iSH+mMFoelMLFnwdGPe85OMqEdTyTlFLhsJ74G8NFtZmD/DOXzINcWsm8dvBkaJMkZxWyME6LR9I8tJHngWHcrfiDhe50VCCHAxN4I+83Z6+7HaWDEsJZL22J/Mt4Q6p8j7eBuDCas1CZVCDZ+D1jIMVU7Horftwbp7tDHrYQLL0W3rrtLO+PiuNHlvtIP+a560SllOXe4/m06orq9xDlgSyUOHp2lH0feW0te4thNpeTuZcN2SuPqiTlH7YVtdPTp8z9AuPB7tEXSmGixe6hVqq3jsRxTKIaU4OX0ao9ccS7slkfbukQRc34xr/L6lf81rLumPeiFU9PmC0Pvr1RZa5CHaqvTHE8K48xGOkDg8yLo0qgBNCIwLIstMPqVfej6/6+aofhlIWo3ezLA0/2gbS8Ce8K4nLdqcQdYMqpB1hY7GRwi2boO9wGxPFxzi8IcS4hM+45i9hbh1lLDif27FYgXiKktBSYhd6yvgtVpnmvg236uzRkw+gsZJ+hV7mE/Esa0r3tYh4FYRcxgvIaTGHsK51OO8QQaGlphXj0+yw2+MJWYL0VJcfGPnKLo3pimrXu9YVSDFpJ0NKxWua8D4jTbfCE70/vDvwMX6vlt72HI64FkYCMxn5OLKrYSv5hXa18h5pzqt+t1/laPQ8txP113IxTnODOumczrMVWgEcpt/DMhBQuBZdsd7StLXDM1tly6/utJHmnq57i+DMKuWas8pJw/zmec/GHPGZxXhsmWFUZhVGe+5pDAjf54fUlgCuulMBk+BfXb2VEo/xqWejZ9tlzmEJA3ox4FcdKeU/2nqePP/54f73K3fr+J/vOQmR1L+AXX3xRr321w8ZbTN+jTVU8sWWtjEwIZgFkFNVLhltSHgoiBdE76TTg/X5vw/OMTaqoT8qAwTrzSuTkya7SWxpNKMRKOH593oe6Fp1r1VP30lwO1oGKpYd/Z5Kbasm/SMnhJ/Yj45FERlKB8VZ020WNs06iO8vK9BKA1aE6rb63rNpbgjUm+SWVx1px6QwvsXJxnevhlREKveG31iRdGybI27RDfxqUsIxCWS3AV9OWhufR45XYai22aivjNSqha7vYETCsh896IY1/rKwCpnDYd+TNHq+EyfQWr9frD74QQ6Tlzp8gWObjab0tgvgy2I56XimJ1+xlvBRQHmB1h6srrKwyBj3CeQlkeBT7oyxS1Y9rhVHXnB+Rd4U08qBeBOWPF4nyHiMhLXxviP22sIwvx2QbG1PvkWYNXa8w0KPNyD8PzAMcGd9oHH3fGN2VAt4xZNHysM6pDTnHDopENivPiNUzSJeGrCXXKnOLfVsbVOgw2/dZJCdPy2zfD7QgEXpDuFuCoheLMPSA92iwfuaVeGDv8GDf2XOjgG2y9tmrbaN+4P1Mmdb9lvxbQ44ooc9wVdfx95l3xpighVwccjh3t3onX8Zyu1Ul89ogE75SIcwC1tsteYqtODSWtb9MXH5JSG4UWDjF48MiDVnIjp/dV3kOJtjZwYhlIP/RAvY+9R4eiKAlqEfkn6qr9Wyr3FLvHvu1a7lMGYY7fT53lHsLlmr5NSGjzC5tbV7yuV7wY3ONZZktwEnQkzPIWKAsFNzTxihkPKVsOJr1J6rXQw0XTZDfYrmP1mm6a/GOV1LM+1gaamTPryn/kH9Y/aoN5MW1+O4YlVIrJ1i8zTZE9XooWN8tQy9+PeVH3U6cjC8FtlK8S1koMprw+9J2tm4D60NPBIUbKpNs3eiFYD3KC/XXVS6kkPDWFoZHlFzvHQ+UZ0st+0x7WaM6UjSqDn/dH/2i8H7SC/sQ1ikDeILU9b6V4PW9ILYmuH4vjmm8UonipEjora32iq/htvXgrgkRrrf0rpMWZOOv+bEp7oiM9fBbO2fAJtrabfTiouZchvYRbr5+5eVgWEuFpdbeD8LAv5Bq6RgzxdGbc+gJ0/d4EBlF4he21O9V1vuxwvc3Va/SVqOZDvj668fPjiEsn9hpuT1REgoJgPUypssOZmaARuEWBfNIuOFWoGXlZ/reKLGop8xi9/dGcgbKeyzCEhxpoweYx9PrgfTE6ksgIHHl1aXAmmIvpFpC12x+YYn8Y2GslufXwieCXtlb1DvRMTao4m3ZUFY0WQswneq0uvdSBOyIgNhKsFwSRoVFe1yXj3vGnc8o8ae5wOvZKi/RgkiYMRwy0GPAsX6rZb1lxb1Gp3U+f0ZJ+ZEIxTywqGJU/llbTPm3lNBYiHgO++TxqCP5I9YRrNCDPx9nzVBUr/JYC0Y0bw/cQh0jz68xqVVoM//8emErBuvlDHKJ97XyEhmIwmcj49FjwPk2ouW7kVIZgedQmX54ycpAFgZcSzb11IMeDPNWGLRkuz2v3v2EyqyGsI6bCdseRdyRJTDqikUTYWvvZAvvQMVMX2ooy0PLEvPwTAf8LOL3chjJGYzEz3vbGAVGZ5af6I3HZ/qW5VuVSF8CW0TIto4EZKM5mecigzvr+baO87F2j6M36qafl+l3n5R7FpU3iNzCGd5TcsuA8fBbD10t8Sp64Hlst1egvTmDka6vkZeIQI0JKi5/vTeE0zLYIr5Y69gSBlvlVpRRt2b9UW6DjZm/h/ez+DFlcvQsxPEt+GzdSPhVpmHPHDhQijnZxGAKpjc22+XqNQTPrQhqFCy36HEwxr2El/fUxKUU1em1Nb2DrdvwgoiFDv33JTmYTFkURoV4G2tvFHyC9VdweV6fgrxwBL3yLyuL2diysgxYOMuuKRmP+O6QkSKwjkXvRmfxN0XwaeFKlMjS6XG5bw2iOOWlcFbvRB71MpfAaRPzZsqkJ2fw9HUsQblmXoLVo0KF+ButzgjnDGTwx7Oq1oK4vvVyeWUwb5KVf5H3qH4XMbatevD5CFTdDzNoFtWg/946cx8JEykV5tJnGFbhetSMjpl6ian6MgJZRRbFjRmNrgXMWhqhTx/9j09t2muV40DBvFTIZ9rogdYcjsYo0+aUOOK+JOfvlicTnNs863k4o/PO739hhoOSf1GoMeKhLL71vr37o74LpOL34cOHoyKuez28XDL86726Z8SAHmUSdYIhohBkgjAzUXpieLcY6jHoEZLFhQcx/LDUMl3qJbRislvAM03K5oqDgbI2R4V8Txu9kMFRWcBZ72MUR8Z7W+UqTnXTbbzDX3mAPfJPjRMzziN50VIw3gti9TLYYaOKYVhMM6rYg5p0W4RCbkWhjPYHXUUWO700XE9RX7ZNnANqPqwxFq02VHl8huGDliy21WOQLO23Wa8ebvF8tF7oocUS+ZeZ/6iY2HyNnlch1cycPxlJbFzF3notiMhLKQGBR+CagnYNYBP82n3y476mZ5Ro+eLeR5QzUNeygF6cmuwKImXGYuBeqKgwac/49UQGfN1bK4zWMSlbQM/YLZF/mfp7Qv6okLKRpkJ4rH7fsRvIlMiIniFGGXGNkMilluhewvreXhgvg4wVtQVcyvPBiaX6eo0hWsNSVeELRV/mIWVxZTTcUrivdUTJJSEr/xjtW9EiVb4Q2cvKMJjEAppjCKuFrO+sWqETdSAq3zNBTupYGOLosf7QYkQLL3oOYT5cUozQij9GAsArdFYv63czNusu+Rhp9Mfwb40z8pkXDD2KZETpKI/gPDww3mbGm8Hxa9EJn4k+o3YL4b+obRZe9XPCDl+NhFLmXei43Dc6Er4c8iCmR1rnX6kIS8Sn7DebBy1ex9Aiw0EZbb1hKsSJOQWF8GeiDx92qnPsu1UUvW+YfVfKQnVWXW8NZg/McI5Nb0hGMQACMsF+8ObTegwey3n/FJOh0GDu8ChzmPA+TsD5/Dll0TCcvcKNLFs1WVpjsqUXpHgiO3nVcyh0M+EMX4fiP4YX8p8q37J2M1YztodHlWC4ie0HyRx86OtFBYNt4Ktz/Sa5yNBi9EJaKf5Xc69FQzTyWDvsk/FNZn6ptlpwKPPxg2qsBJMcB7zHPW5dQ0JEln5GuBzrObyv3dfLvtu9Je4w4s8Y1L+T+XhPCISIERWzH63IqRSMuxhNq8IyZcasyGgvCPWsGqcvR2OpJoDiyxafrQnKeFH8l72uDBA2/uiZZAW44j8m5JhgyggWZrB4oc28BqVQsBxCdJova08pEVTYWWM3kjkRT0TPR/KPlWPjGJWPjEzVz6i+4vjqgRUw67yuD67fqztqZ8DXNcB17bC5qFUms1ASY9yMhrN7LQFuDGHtGHOY9Xym5ABH6w/iap92Br5ds/56BoysgmiyFmcF1c+v58czIc/qZAIXViwnAAAgAElEQVQ4so725WZtdU7wKNbpJ3lWwZhinCaeV7P77969K+/fv9/TtYDVaWvSPZ19fbYWfU3FgTzg28MX7LCxVkJeKYdI0EQCwvhGKZmWpxDhjO2oOvwzdRz8s/beiDquqERQiCvhbt9RBihvxuMc1Y/PKEGO44/0MxljvFvcmOPYMwEfyTZF6xZEioT1zfCwPlR5WMeuzslC+MzPwfrM559/Xst8edaTliWI2jrKQ6CQZYMSaXP/x1YAYR3colsW5mpdy2ry0GpxXgAyYQs/pGnru3keWBbrNEC6s0nW8gbYsQimAGwyGp+gAkKhbN9ZXoTxRgaiscE+RdcUX7LJmxHyai56YEYM6wfjKaYQmeGnwI+DUowYimIvjoreRuhfAlWcMlBKxisLu49l0QtBWkV85Y0KpWQ8fUflH8NLtVEI3Vl/lEzp8Ubw/tEMZ4iggIoIrxrzROyxGFlH1G7YeFB0m1mclli6TGgwKwMnIHO1Wb34nBI+vvxUTlewIfPZ9+jVllnlw77PB4+uOE+QKQjsoy9XrSVmdWeFHwPGp0roZyc+403WJ0VjVr4HEH9Wn1IArb77st5bnw4h2pbnYaDCUi0PA8soDwWViPeovdzD8Yp4KfNirCXyb6SOSDa2jGF8RUcWahL9c9UIWiuR+4eIKWuHdVBZbooYBZJlzBLOQHYwmLVIJ5aojvVP1Y/WCqMl4umZi00E1q+WEivE1VZjxCxtpuw9HeyVmvWvCh/kg8mtwkIBqLwA+/N82mu0sAk0KrzVs36sor6hUiwB/0X9RP7D8iP858uZ8mDGpgL0HphA9h6DSpZjHcxDwXLYP0WnyDDNKg9Vl7+u5F9rzCLcWTtYP8rTjBz2/Pf1119/c4cVMkHXsn5ZIz1uEU6kLDCB2SJkFtTgqcEtJKdw8tzE65Hlk/1gY8cY19erBDsqAJt4rfFXFjvWrwANExSmik499MlCNGnZb3Utg5eneySs2PxgSpsBs7Aj2mb5Tyl7fC4TumKeg+c/zx9MISiPxAPW2aKlHxvG/2xeMDpmaKnkX2QU472If7AM65MPCWc8GfvcIfLRw0g0xbzZSas6mZmQflAwHr6GAkGcWvcY3if3Zo4bPq/GAJmcKXv//cQiLzo27/9a449tRuPvQ1AFXOQCIY9oLDN9x76MrqCLvDKFC+t/tv7e51t1R/zXsmp7+U9ds+tsuW6ByMHJUnGS/zDwSogpk8xqLd+WilwoZT7C/wgRTbGtEYPE46eMONYnVobhpXj0bBWWIgYKHYWM19pqQKJOZO616l5bgaAFMSXcX4WLn6Ro5Xhaq+cM/ERD7+GsLUBLeg/TvoL9dzU5I2+DCXol0K1+y4VYOavTr3BhStrv31H49UKPIbRUaWCZjEcQXVPPR/xXYL5GdSGPMi+AWflF5DKiOtATibwNtsKKKQ9FG7TiUa6wMup5vLZE/qn6o3az9bJn/KpTJR8Y7jusKGpcTVpWsep86/kChGd/jCFaFtSaELm3isFw0iuPoICgjGikrmFbWJ8S/LvGggNmTER4G0MyfGvyfDrk1Sz+OgWhEAOvQCIvpAeUUTRq4CjvJCPkmbBiiq3lLRYyjwrwXzSeWRpiOfQ00MsoQbK7EOHvn1EhL8yVYF24kgtxV/RXBqLif6yzJf9a/JBVPNE4+2eYIRzV3TLi6/2HaZp+9KMf/Wg/oesa4E8//fQ4sf2krn+ooZTAbhGvdW8Sx6V4sL0odb/A5BKx9bP1bBEELoSp7NPOxzfAJH4REw8VTWRtKgb1OCoGRWa3UBAKWvvt98Gc9Xl6yuegu2/Pq/HHfvm9Gr7ftV5bb+6VjOe5ugcJ25sh7h4ZDFkPQZVVyjhTf6us4gGka4QDs7C9EPHG3gj/PcJGV49jcaFGHBfExdfjFQBbXssUA1M2uLoLyxbizRRQaiY3GE1MhjBL3OhpvGr7XZAefpUg0tdwixQBG5uofEvpqH54evl6WP/qfK7X6x6Qev2rr77aJ9EfWIMM2UIEbUt5RBZ6AaaNmJsRZII9BKqNNUANALathBF7rkVLRjf0ftAaxXO2CigeTJYxa4gtBlC0ZRYLY8QMjVr1s+tbjDXiFXlCvZZ6xKtqDjBl4g07X455ZqP855/L8p8qV5yH4HkRvQr8joDRBxbeUuEztpqL9TVqH5U5W6kYjbWSFy35x+Yqzj38zdpW4I23Fvh6z2JBkbWTEe69wrxHiHocvOWBFs5oEnVff2PjYUsQ+n4oRkKBwKz5Y9np8NdQzEeFWqYTepwIwN3zslmm2D3ObMm2EqaMRo+wex3/sO7IsMgaFaOQ5UFG/16DJxLu7Derp5A9WTPkJ0b5j/XVl5mE56eUSLVUEZ/q/bK8CPNGivMcooS5BwyfYR2odAsZeyXkcdytjRk2wSL/M0OKtcvaZ+OAgHi1+Ejd651r1fv4it2Y3GYgZNYSTPxCGLYFzEJSwCypAoO7RIHUnfXZY+JxgiqL/kxoTPvlb1JIe6gKgTEdKp397nIR4jiGHufzg+SUAsMwAVVu5Fqk5FQfEGayikt5Lb0eiBLi+BlZkVneRtrinGEWpVKYvl2m6NCwivgvEpL+d6935euxfT7zIZxjsHNH+GA4yoO67kE91yrn50ZkLCANmML088Ou1f7aES8eFN+MyD91vWUERXOKeUhYjw+97Xa7H5yFsDzD+zg6K7OW1TiicLaE7DHxJxYJPMI8EQOlFE6ElgtFYb+pApj5RGYuNj6L7ahx9b8Zs/WMPxOsjHYRRPzHoJfPfF29igPxQes9ondUF9arDDnfXmSxYnn/e3ZeY/QcG0OFl1d0GE5SyXGUP4+wSRDDYOixMCXT8ioY7qxvzAhkYcQIGG9FhlivfFX1+u+4N0YBbuWoO9G/wsoKIU6mcnR1ldWoLKySnKjK84ja3Qq8AEc6MPwsHOX7bNdOhMp8rlSw/5Ggt0PtDJf9ybtCsGVp1zP+LLHLJqS6nmmP1VUSE7+3vpJQTv4ZVBjF8QGzMFGZR96PUiie7js4CE/ND2wHlSWOXVbplUOYSuUcTgRQsBudhbEUKG9GhbfUvGp5ZVjW08wL1yz/+/oYDohjacyZFmTmAMMFZYXBjjEHMt8ONndFE5QxaNT5aMBUG7M7K4otAc2swspCNFh+ojH8qaAgXbRrOBZMCCAdmDAoEJudDhsZ/ZJZ1g/8XsT5Y4oX/PhPZLm1F3DRZB2x+reAFh+za8gPyohq1YlCvICisHHEVXJFCADlKRTSTyYLMvzHDJLiTn218mw5rlpNhWH0Ap7JDjYIsroeyeZF7DfzKhT/TbDc/BEOAPUnTLPnWA4GvzNgYzFiFGWMIWZEsHZ3KKSYsHgW0uchFCxbxOTKTKSWBVkcYx4ta6dAlCBfAmrSRXRo0VPRBCdkS1EruvljU9DlrMztN+lF/ShwrDNTiGqC2Z9XGGiJRdYf6yejwyUg8hoiOmL/FI964Y6CPhLebF8DtoHttfjP1xXRnY0j+/RK5PGwcRStdLYSy8ArAZVgZ8/4MJjKo2T5D/l/djk6RTOmSBUd2TNF8DerLxpHVQeCl6MR/6HB8vD111//wmeffVa+/PLLYuvza/ijrvW1B+tDP/7xj/fRe9s/sIN9Bmjd4iYyHKDdfkUQP17Z8JjcMl1vxTy6vQyGw9df1zXKp0t7923vk8vnE6flpVR61L0I/rTYmhh7QnA6brpTFoFSHDg4j3AyqN9rw5jAnvnkk0/2n3U9e/20kMG+jnJqgXpryd7xUoBhvZVmtGUrfQwqLXy9kWUTKVJvVfm/jGERCTm08rAsS6T6MhjbxuR0JsmPYxiNKfuOdflxY15ccfT0+xwQ5kNiO1rR5Oci8svs9geUg1GCdVgSHXHzdaj8gf/0yXhfZ8Uf92Z5mWP7jDzuHk8L8Rpg/sXT9hFeaWDXbDWZV2y2Hw37xcZvdu8Z8nw1wT6o2XmdHpSxwMYbcar8YbKt4lDbq3+7w36Peq/+1XI/+clP9vsDv/jiiz0Of/Inf7L/vtvtvnrY7Xbft4dq4UoAW0VQf1dBVR/2na3XaiXFdcJeSGKIegbDtdj1tw3wBC6jgWec+mnCm2nKp9/V0jhP7rNVVRlvpSrVE0UER6xjIg7rioSHp8ksvA5mzVpZGx9P0wLCOFq9oiyYk81PVUnOz8t+ETz+2Jfp8MKo4oQNE8LWX5vMnn8qf1hoAJdAoiBiEyeaUCOAdZnxkgGGi70wC/nPyvnQIeMz9CwRsL1WfgCVEVqirD4vzFvKtIWfbxPHltVXhZrCrULlvwgf2xRnYG2Z3KkyzgtuHIP6vJdJXu7hNSbAq0ytZb0it7lteKDl72nh538Eir+8ArX2bM4hb9v9uuG8Gta13De+8Y39vaqCvm+aphaoHavEq9/rX62wDkZ98D//5/+8VxzmiqIQVxYoAyQQY0Dl0pnG9M+quKKCR7Gj2gtTDI/5yY3Wzxy4swUmx+x2qqJQRAWo6qvjhQouIzR9H2YIhXim+tM//dMTK9SPRf1dJ7D/7UMG9Vp93octCigdTz+knbc20SvLrBZBWkQKPKoDhagXKEj7XmDCEb04tYzV85/Cwb8RsBAFghY3lvPziwF6HVifF3AtY4pdZ8rBl/FGDaPBD3/4w3D8W+c+/eAHPzi7D0tYJW1m974bBXV+MJmh8rioXP1cZXyCBjiCvVnWl6/XqnIw48b28JgsNJlRvY/D3PzwMM/zOytQhYJ3rfyKhVppJWoNZVXr/Dvf+c6RyX15Q7yWwc4fCTyV8o3PvzghFLO4cVB9GRTw3nr1dSpmzSo5W8/tB8wrAIa78gBQQKDi9RbBU8jwCXCyGKP5ENsjHK2CrxpFAVLHc3ahCKvTQgO17glCYGixFCfoHuFMK4+7PzbF98P3B5Wnn/y+bqYomeGBISqcqH6dPhMiO7e+v4BSYgsLihCCSqG3nm8JICXArA5UAEpAK0ALF2nUUjA+VKrqaYEqO7mIRCG0nA4REdUm8i8bM5+YN1nDQl4ISH8VhcFjfvwnRhh8+2wMvSzydTy6AxJxgUF1EqxcfaY6C+aBVCfCyw+rv+qH+uf5/wG1ngkVcwGrIqj5kDogVWvW39/61rfOXiIzQcLMQlQK/AAyS5TtlvYMYB0xwpiAn2FlivIw/CmwdYkr7s3YHc7LMU/JCI2rRFgfioiR+8E3CxIZy1vdHm8UrhajVCvk8A1xBUINlcHRC7PrtU6vwLzgNPATyiabTRqrh01Mu1b5y/itMqs3QOZDjLY4Swu9nJYHEVmIRQhwzx/YhlcgM2yOY8+XBv8xZYv8h7RTFjh7nglfbAu9Bg/GWxGdIxq3xocB0ogpdi/UojomWAWIfWUKmtHZANtXsonNFQZ+frBcI+aefFgpo4TRS0W8rX6jI8pOL4t8tGBy6Yp9DsTeFWFW587tFDWBUIW1aczagCVZcHA88AGej5ulDTkU9kZAe94LenzOMxLmJwxQkOMg7MuTwfAKybermCTyoNgkKMQq8MBinN4DqgLWFhpYGyhAihN8/t4MITQ/6ez7Z198XsrjM9OxZJ+v3/jCGwDFCaoZjnPwk9wrIHvOPKTihC16WQqUIPfABAiWY7Qzj83GB8c00zbyegGFjHTC74XwBxO+/h6jmW8b75vQwDyJPWc5BGYkFFBmii8LzENP8wk8PayPebW+DQuxKmAHw/q+mAGj5IfJB5zDVm8rR+FDtI/iwFDss8cV+x8pPfY87pT3ixcq7TCvNbm8Znme/189TPPzgFTXBeNqtTIvqCphqyfy0z/900eL8RF2fiLjsY56D4VZ0F4weWbbudVfXsD7nEokXOw+5nAKTGxLcBmxrPwjrPlGIcwUzkmfpqe3tHtF55nUrlevz9OsAEN5C/6I+/S8p8S7ruXA0B7X+jwykJ8QX394mgB+FZunq9Xn+8CMChQG1r5XMIUsL8aJ7S2iAoIGBRBT9p6WE4QwGM+gB8AEPj7fUhz+nrKgfZsRZCx8pkQyUJ+rOU8mlAxqJCLqr7rHrGGlZAsZH/vtDQzWDvPAC4x/1L7xsp/DnieYgvL1mDHOQl87t8q0OFnhDSVLAeAc9QoAgRk/HlB+eCPZjDjLe9tiqke3kKUc5mml/SFC9eHh3bt335sPyzstLmadMCFTH7BlXPWahbNwsAsILjax7bslgVEIoUdytHynpyNALLTjBcsjObaAeQD4WxF4OuQgalsW6pndMl60ALyyi1zkY/uQaHuEw+Z8+Aq9HCvrx8YE8p72jm7FJcJwCbSPwfo+2J+fQFbOTwSWGPefLMnJXHUmUApYcL5uVBhs/LAtJjxtGbKKbfvl26h0kBbYTyb0EO8qQFTCVCW6Ef8IkGYI3mhh8xQtb09jUzBKSbM+rQ09CpEBKgQE7yFg31Xb/nqlTyE8YeDlWIH0gXm5fgxxfinF7o20iP8sYuB/W9tV9lV5/wiHUlZZaGUO9Pt/Hj58+PCF7f2oWs/CU1WZ1JUM9SFbclYT5z/zMz9Tvv/975+tcvAdKGBpFMJk3sLGAfAaL3JVDXZksxDDyf+u+1BKcObVN7/5zbN6TJn4elg70QD6/qk8D1pSKGQ9fdCTQEaz/JCFI9GCLkRAPZKdu97FLRDDZQpa0QD7qQBXaWE7GEIroOwyMWj2vH0yAwBX3inhwK4hr3iaqxVBSoAXUHAMnxb/eQ8ccVRC03+2FLSvQ+UiIgWJoWts3+8JUfIHn0e8IkAF643E4nIEqn22tDlq29qp9fpQ0ZoQyZqKb5XvVXn88R//8ZH+lu+wvtv1uqDqyy+//J8ePIFUx6LP0mCiFuE8cbOD24KcdZJrK6KPsuCy+DGmZtZ2pAwjHFTZEkxqbIdZ6VEfWwKpB3qfHSnfoq/qG7vG5kFrfkVtZRRUD/8hLoxPmJIf5T9mmGB+shD+e4Q9D75uxr8M30i4IzA6WNia9RH5bAv511J4Ub3RvaxH9Ug2RWJYeq/wFMMxQRaBYmAc+Fan1oA162v129PpxBOY2s8qmrGJ4+9lJnSmP4+NA+q8NTVBLgJxUEIoGn9Fu0w/Mv1rlUNhyhSKwl3VySxff015YegheJwyxhXjC1Yfa/uEbwM6qHYUDRjgSr5oOSzrC4NJ5LxatIv6GEUaFA6Id1kg/5hCieRCq76R+aTmgqfHzt9QjIHWsJr4WcHVsuRGYY06lsCJ4BTHqx/vixU//n5JTgjGHIopPaA16CeNP80XwSuRJePfsnzxuVa9o94H+/N1MsWgcIuse08v7F9EHyXoov4rKxz7pXBjY9PDf8xDwFBzxH+IO/Ib4jfBQouWhc7q8Nd9iJTRC2mG9ak28Xt0zcNEFuWoekeNoKyB4eFslCPCT7D6CLVRFlE2GFnit+q9BHg6tPDITHx8Bpm5pSBwgiur2tejLD8MMxzrnmJLr2cMImWR5QsmBLLts3Zb7SBtVV1RHQp/JgzVc2WQ/7LeCMN5lP9wdaaHXv4rhDYZ/mspT2bpt/rp299a/uGcyOAX8UYPIM+wcTlmqJmmjzRdZD1GDKesmLU6mXiiZPMfHpjFpnDJCB2vGDy9mZWjLMvoOvNcIiWCyU2sb7/cuzwnEhkOEW2UsGYTOWOhLTU4mGKOVokh7mycSsAnzCiI6mF9bQkSxX94rRDeYfzHaJTlPzwLT303YPtgIuHsV/mxlXSKPyNF6q/hsnM1JqqNteRfS0FFXoOam4xHsWxrI+6xnNJaI5pVPavqiazzbNv9ymhMcY1YAUVM2AIDOcrkDJcIJ4aH38jHVrL5JcAz7MtReGTGX1mA0bUsZK1A/PPXW7yp+C7DG5GCQzyYEGMGHPIMPhtZuC16jfCfSpYjjynea8kfpUwm8goDpWz9OLJ5cavyj/WnJb+xrpaiYe3ixtEKD5FVlSGaQoAxdQtBX1+fUohx2RIiZkHcsO/MU0Gl0lIuqpzCxa6pPQgePw+43wPLKWtU4Ybl/LjPEHJj9FB9y3gf0QTFdpmHkB3zkhC0o+U9bi1cPO0iwcboHCkw9umfVauuivN0lXfC8FV9ZOOl5A/izepptR89w54dkX8RqLnF5tPaMhF57mQZr2+wWp12/op990f+7svW16QWE/ZPx5S0OhcxBCqOluWE7aiJMgLqqAv/XTEs4qfAD3bGku/p19L+bwU4gRWerYncOzEU3y2p41ZpjICGSmmEDFsKEeeZUh4I7OgeVB74yeqqHofaSc76hPIt6peXfwh23/ZWqb0ozAhWdCqD8q8FkWHp60dPy8BobpvL7fReO5n98P17OyS6ssYKbN7aP3cSDjp1/RlBGZHUtajzLSt/rYkdCbGIYbOA9MW2b1FAjXqHBijMUBj54xx8myzMURaOdW8/sO9TI9x1a9DClRliUX/x09/zwp/lOlSMPdqfhAolg1sR8qflFSjDTRnIWN9W8i8yuhgoozbywgzUYgZfbodCDBH0WlkNHPMGGCHWEvATiV2zzi0FxQSMNmyylYbAjZTPJYRS5rgJZskpfBnvtPhB8USvsFsTeifpljy4dr/wd8R7zEhiBoCSB0wZeMAwFjuSqBDvJApzKcte9Qu9E6YMI+8lY0CMyD9ftjWnMvME5ZeaP6puNj/3hl2mgsjqYM8UPzjl/DllzUegOtDq6BJQbbDfONCKARhsIQTXgDWse2a5ZaBX2EWwlTCP+OEWxzTrQaFXyJSFMqbsO/Me2LE4bDc6K4NH6bR4QQltNJY9DXz/0GtAucX2rCh6sPZb8g8N0Mhoy/DaKD+25N/O/4i06QSHjynr+WwQZ26tRO5fqyMFCIztr+mBrK2Q2PdbA7acNaJDNJmb1rkgQ6+wuxQw71zhsibvjNaVMawUDaO53WpTJcxZHoSVw7AV8zyKEPQKb1QQrF+Kb/E3hvNZXVkFvES4s3rW4Ds8ukhFE3aeYMzNUa5dltBRCGcJKFduXOj3T7BChIh6VlkdGRd4pD9LaI5n3ihl3WofwwOUV1zXRoXdNZRxxrNaE681LEiEFp1R6JVgjJgByg7lxFAU7j9S+0VQ4SjrG/mV9aGAbCsg/1Q0wdMT90operfknxqDHkNJlY1kYcs4yB7lchbCYmGZLFFGwkijVs4JHqvMU+3h9FrfhdBICZxseGttb6gF7LTbJVYwKpGTSb6bjp9RHZeCaNIrC3ItZRGFKvCvp05mnUa8zUI//rmWoG3l1/CocPYcO+TTe8dqLvnPqH/MsmaGHaMTO+ZnDR6NvPleUH0rIFcKkUvsaBmGx9lhii2NyjqEiiYa2JYgzE7EkwlcTom05kAuEZrMU8vUdw2LunTsPs2A6jdjYvNCbBx7hV0L0CI9a3+gX1sBTvgl7UVeUsaD8mPGDCpFywlellbgWJMCuQ62rDfixZY3guPN5I9SgsoYUIKYta+gx8NmtI2MVcQFQeEXzYfoBG77TV+2MR3emGavNqx7QOwFNvYeAn9eP7Mu0cXrnQiKKPbJXjhUYABmsRx0Euu8FR6RFaP6x5Roy9JRbRy/uzcObg0nk3QKI3whzCK3llEIJ/Qq5+vo6fMC16WKI/PsEiUXtcV2APc8ryZ/r/eL/VPfi5Mh9hy+IXAO3snOjoFXEO1yt+f8m/XYcSlR35nCRPnGxt0/Y8+hcmztI1E4RdDqj6exvbbXcLSXz5liN7qZzPQvAbT36ZyFsHxn1Lr7SEuOdjgrRDNlJhf3RC3aa9W1XHwEpjiQOaKJVwQDTYfzqLYCjEH7dlvKo9dii+jHYF8Wiisa9Sq6lkK4ljeIeCC06DfC66oehosSnqh0SkNhqXOxipA/UdhLna2FbWX7HHkBmbpavBPxF5MRaxknakyVMovq2EWDjK5l5uz+UUXQspZ6wDM3DlLrHRgtYMRW4YCl4Qfmkqsj1kf6EK21x3bxVcLKm1oTIsZmXm8B4+G1AQ3/Eb7ZStCgVZ01DHBssjIG8yQ4bzE3EskobAvxnUmeDkNTLWWq+q9oE9Ev4vlW3a0ykcdUhGJTfd/5wvgg0/KtcETE2KMeyaj7jn9Kk/fUjwyHrm7kfvZO7JZlNwr2PFpzzJKLzsxKK45BWa5ojfeOzTCvLWHhZeCaCol5/CUQ1iO8pupRBkNEfxwvLOsNGOUloOLA1VpK8bDlv1g39hGvzSTBjsJXJZiz8s8/zwwhxdeKB5aWyRq/OCdPkugREVrHSLSYtjUBUTCqSZMFFdKaDy+uV/1AnJUyQJwzYSnVRqufKkywBKyOyCNrWXQ42dYKK509n1CcEf8po8d/Z5PrWt5NVvi3eGZNXNQYowFVYMz8vEMByo45KeLFU0zRsOczEQbLXyBPoYflgRnXGH3Iyj+fVygwjxhdEVqyoGUgK/k0kzwXM9r8710h2tFbqB7w4K1RLYZIFxigNVxwz0g48SOloHDZSmgor4iVWQq9fWhNRJx8KCj85869LU4J4SW0btFo1MvsfX5N5X5tUGPZMriUZ+TpypSEAfOECzFolKKJVnfZ94xMYBCFerLyb+feuRN5OwqW8Acz8mYIwSEuc5AS2EUEwOu2kuG0nE6WoVJSmpFfXyY0jYFQQakcAgrDSJidlG1Fb8jKFWSca8AJzQdX7yJDtcIaiiZY1sNJuQFSMaspKqOMix4lPiKM/DX2tyUoPFrzV/VX8TyDlhLxwPIh6iwtVl/LO0GhyXjH+N1vtlVGYES/KJfZy2+qHwy/Xt5kyuakH9mH2KqGA7rS5Vedwuv83jLBypigx9qYkuGZaGVUy1q7JKg+7Md0cE1BSxGq/qvyLVqP2BQtLxmvtRRMVE8PMOG0taJgEOGREYxYrsXv/j56Gmr1FR5vUpwVj7vbSynUC2E5kZbhG0UhLBqT9WJ65d+Ix9xqu0dhoUei6jrbB2IV1TyBreO2s+DrYNTv9Zpf493bIYYY3lMdUsSOCO49kewkjcIz6NrjAEyHNdVKMGE4IOu6LgHWBzapeleoTSR+y/qchSytt7FjI7UAACAASURBVKJVj/WHnnlvO2vVtQQUHp7+7HoGohVWUV6DJcLR0zDAhSDRsuCZJL+x78p48XTAehiwuW91t/agIJ2ZN1iITJSGFwGjm/Wl7uuY3P4422dX3wdi7dUy9X1QJ4oUq265nzoU0Z50kcLw3zMM2itAIu2rri8Nz8wkvukFoKLrVhD1AYFN8Ih2awi9HlojTS/t0XnoDQtEYz1qkG0JqLQZ30rvViy3LcTjUPs5MntEVN6kwDxkuCulWQL5ZyGoHsO0R/7h3FpSv2rLl2f5JraHDtt7YAygPrHRUy25/1+6t5FmHBFE0WBEk1AxkSrPnlHXEDemYK4tDDywPvR6I5foT4bWa+HRUw+zDKOxz1qcqq5rQk+Yw8ALdWWQqEQ3u8Y8kNZ9Nu+Zda/ozcYE64mU6BryD+vt4SOEjCeZ9WL2UYyM9ea1biEC0r6zevA6MmEU+thCOD0KT0nh3sKRXe/BuydksjYsbRcn4gis5W2u5QGh5xnNj+xEU89FRsrS/qxBD+ZJY92RZV/EBj/MTUQrsB7JMfCRZ+PvM++/AK1bXsEMeb5I0Wwl/9YcS4+XB5YbytS3Q4EXWcs+lqiQa31Xk45NnhHCtZ5RSe+IwKN49AxED7SsjEvBLVnIW8Ca/WLjPKqALgVM+HkhyuTA5FYp4QY/ltDuybmpMFW0ugrDxa3QUDQflWEbybyWMlhT/mW8iqh/UeRGwW4CrYyWl2cipaUy7phCblSAss6tbamO4IYDtbZ30WPxLxFII8n0DDCr+9YFqYIe/s3w/1a8sgRUaDsT+i2NkwzQq1AJdPZdhce8jGp5kUwhsr4ymeiN6UjmRcpgbfmnymF/s/Xhgg727FnQ0WtsdN8UUi3E1f0WgRWoZ9YKhxQgdq+QGBGmaCm9RMiGQn1/MxN3DVi7viy0QmCZMMjS9kcBBUvEo164zocVfq1Nfwy8N4HhqxIoIv89WmlVAkE6kcUCTP6tEfotnfLP44TPMO8mE6Xw/WB0RWXM+r1Dd1RpHKUo1EDgM8xjYcpodHCWCvke9y2yaPA5NYhR3RGc0HQjedgKB5QOehdCc8YXkUd7DcH/0pX5GpBVfJFiUauomPdhgN5IaXgw7PysQvhMhalRcTDPuEf+sWeWyr9I0TDhznBXCmciryv3G7ERr5OolCKEPVQrtpNYvUvT0shRh/AaauQlQgrxx7qNWC1Pyh+LgH9K4fp61E7TiH4RMzKFd6l3g+DiiWz4Aq/PIqnpIQqPLIFRA4NNHlZeQU9f1u53j7d9du3rx7KbdjXGvR//Tz55Vx6/+rp8/smn9YG9TKh//h0S9Xt9Z0TdO8CEO4LKadR61B4lPxcLScj7skz4ZT0oxqOef72Surb8a3lIOKcMf9urVr/bvg/b3/fu3bvjd5RP/l1MD6xzviP+YXQ7MwJPKSfl6djva2yo6lVYGIbxEFnxhQx6pJSwDIZ5FMNhG6PA4r299SE/qTq2svqzvNQaHzUOCHjsT4a/1ub3LE+zdncPH5XH+cDD81zev/9QPvr4oXz5/if1geOGs/0L5g50qd/rZ30RnQpXse/ohUxBEl6diIHzTY3N7DbQZukRjW+rDuXJtORfRm5mcFfXW0om6o+HHRNcrJOz233pd3YzpCJ3jQkhJlQuHbboFVyRu9sCZi0cP4NqWm4wY8rILe6BlsXF4NJj2IJevNn44PfshL1lUPMvIyD35SD84f8ULfCokShEVUS4qgS5FIV/S1Ayb+VsjgpeUJ4N3svIP9WnqI1Wf/y1Xv5UEZvdLKzKyHXHGCMKfdZRFLTKguvp2BLB2JogvTgolzWaRBSvRJe2CvMgtCw1BcqDOsINytYRXmDjcIlxycKIos+E7tDrVUZfJOzYzudCeC7aP4LPIox4uNhP9CIL0EhFDpbKv4xhMupdZmRSlnd2LWHElAtzz3sQZ/dHJt4SBZC1pKOBzAxAi4lHEuEZC2K0DRV6O7neqI+FeY6PTsveD9IDkkYJ/DNle63BXtxvwYthUQk1bzKKxH9Xy3IV4CGJbB9JyzucIOybARZ63cH7PBTd1DVGoxZOiENLho7U1zJ8TzxPe6EUm+xI6KZVSVy+DOKI2Fohl7VAeRazi4e3IBKmI4lwNQHWbIOthCkdCoDxlf/cJd4PshR6FNjaym5JaOuWwl9ZoZQ1CK1cTdAa4CKVErwPnR2kmMVDKZeoj16wMkWCz2Vkl5J/rA3VN4a/EvYZUPJXyRn72+HkZkhZx2z1kl+Vw1xdhTh2lMUWRycPJfrK85Ap1CzD9AjTTH0Rfq02MsA2d/n6bGUetu/bYF4Yo9tWAjOiB8N9LdpF+Kj2bwVGx6VlHWM5JfRaG1ijVVgMUOj2GqhMaPvPKNSH0Cv/soZ4j0fF5qQykvGanyNWZucrycQMldBQHYmIqwZkZHLRZ5J8opToWXULwmxZYboEMm30tMXCCtGyTAM1hj2M3gv7eqHJiB74vUfZLRH+zMtvld9a2WQt8x5cegVaRpHs4KVRrRwdE5ITCWEpvmQy8ZLyr8WfWFeG5qzuJfOyeiDvrTIbNO9etirPaK/iBiNDiOg+lkXXy1aImYU8Q5JvPrzfBHHDwfOM6nH3bUR99nitKUxxUvg/ZVUzvEag5+yijDHSup6FY58a1fTQfAtlt6UCXQK9SozN0d5+RcpIJcgxga7O5itk3rXmBhOoKFv8X13GPJP3i6hTh5fKPxT8ar5ngOGBfcb3fnh61feClKf9Ol+cvNIWXanZxfknd/5LNBCKIJGXoTR9pl4GLUHFnm1Zq8gA7Fl1rUeYRtBiul68eqHnfKytreaR+nv6voWgv0XlEQEK+cgY6VWOOJfsO9v70Vpx5duOPAD8rfrm5V9UF7bNYG35F8kwBpEXVojCQoOb4eivn4wGc8XQimcd8n3JCFlETFkjWwmh7CAodzIbemDfR4ANdi8jbQXXbr/gxE6iE/F0WP8GkKHhJUJZCOh1l8M19r6NspDnMQpSyAZDf109r8JJOF+UMlRzXvWJKZkt5V9GZrWAyY6WUlG02M3EsmbaWMHTvXNE2ACtFcrpIRK2VQImUvUw+rSeXeLeq7qQ2dBLvBVYGxfWP8nUK8l6NeHfEvSGWdait4eM8oieVwqFGWNYV6Z/LLx3KfnH8EaDnyl1LLMkGnJ2nDs2dFJ47z7OYewRkWWNtq61oK3Qcp0faZdZOkvw7Wm7iPglfldw6RDK5FZltSzoyMP19fnvzFqcOle1RVbeTGLfPZ5LT/+3gKVtXoq3I8gmyjPeOVr+paEAlAzLCN415F+LzzIeEtbF5lNWZjJltFNamRH1SXHEbmovUZXGHoVMaKeHcNg3HIgthfJrtHyzfYrCdqUxIUasv7fqZWQg8nDX4n+1HDdzMjRCb5iH1aVkUq8h1PJkI/mn2mm1H+GoZB/Ktmh3vy9LS7EYmK8UT7NFImWZKooLRsgvhd46Iis1Y+X1WKyZOkZ3r2egZ2lkC5YI5Shsx6DXCInqO6lnZb0SKbNbhZZiXmNOKr5TGwuVV5f1mthzKF8imTTDKi2sR+ETyU3Vlr/e8mK2VDrM2NqpCcQQ9fsCmDvTa82xQWuV38JbyZRTjKDwxw1PHtRgRUxqMG18jHtrfwf+jqxAz5hrhJIYDgq3DMwuf6RovdWxKy/N44m8kLX70nvECYOWoPWWNPJqEfO7Jah7oh+lU/55/JgiZ31sXWP0sPpwoYSaww+Pj4/v7EfdO1H3SNSH61rfuta5XvPL6cz7mI+rr+KQFiMCQ2qGeHYrFHbKUPMRj/2zZT4eN43Erb/t2OkIlOA3wPXfUX3R8dOtZ5mAU4w0P55vpsu00QIb/16GZ99b5dc0ELKANE7R+sI4XhtwnkYKZQQml7s6hkfIwYq4KksJbTbvM2G4SDgjLkxwZ+Yyw0nJv5a3ivMmOzbMAfDgo0w4B6ps3R/jr0JYqqFyprkOnS/tyYWdUi4ke64NUNeGx732hK4y9WQGm1k+9Jowl5eGv/B9IFtYz1uFkrK4RlbmmsoiI6BuSTlFYZ212ymBQmAeCONHRrteHmC/WxGHqJ4yIP9QaKs++nJMAa3psZ/B5JbxFkGcKERx/F700QCt+lrMmWbYC0UEkKlGLWZmObQg45lFsCT8Nfo+kOxk2yKUxCYlLziGewaYwlChAw+ZeXcJUAJ6azwyiqSlOBiosHILFxT+zLD297eUfxmvpGXotq6pvT4n+M+HHMgk4tRew3uEVOcZMVRYChmkN+RxBhsbbchAGZc1Az31ZK2J1jhkl7mOvg+kha8Hxvg4ARDvNdvf+tlookZjsIX30wuKr9bifQ8Zzz7Dj/YsUxQjiqMEcx/bXVP+RfKwRffMHGmF2lr1W5kTijJN6zvj4/ZYET7bsqAUwa85YSLCL1ZwpK01rTgltHpprCy0nveBjADiFuE9Src1vZueNjKhEVauLOjrGsBolTEme7zUQuQIo4k6hy3yVPAthv6eb0uNgaI96/eW8i/D/1mlPruFA3iN9Y/xgC+7wwoiKxffRMgaYJpVdVy5xteaND2afRRHpMul+uot+6hNfFkPXT6Z0CBMoPQKlkIYFu/1tF9gomc8gQiv7HUlAGYIgY6EZLK4bmGs4NweVfBRX60utQor8lbUe9T996xwzigEVs+a8i+iK1PqWLevvyXDmaxn/dupShiC6IFkXatW3b2TZW0vJcvwvZZKVMeaHldv+KvlgZTG+0BG8ckK/Mz10WeWPNcLaJQpIRMpnVsApIsyRlAxrknDXmi9JwQNiZZwZoZM1usakX+jXsbovV4DwMo+MOaItHrW1Wld7ymDDBlZpSOQdT9Z2yMTpddSW1uwZaF3Db4XLJFbvBW02o8mOHoDa4Ga9GaQbeV1LAXmqSH+Cm5F+eFR8PW3HcOuZNkMeTgfKZhEfg6/e9hK/vXUhWEzJeMzniref7BKK2Hr33RIVrYq8PsCshqLuUrKjYuQXhuYAFH7NPD31pN+7VBGqz48SrsHWJhoK8HMYLR99VwLRvuFExqFUuQh+Une0/ZI6JC1/VIg4l8VdmLyCMteUv7hePdGOpSSaM2F+lf3eZg+KIe9H+VA1/q97hf86KOPfphelqDccUaUlksWWYKtGN4WEFmJ+L3Xe1gKa7bT8qxK8o2DJRgrT6eMyz0Ka7fPnstA7/gw4yhSHpf24hSMKK1rgjeEfD6E8QSjvxLcL0X+tTxuBpnQKpbZv5EQC6AGtAeOqxeCDWtIhB5ijsYQtwJPrFvDbW3wnld2rfyllemttT8CJmBMmI2+0W5L/NhvZh2/BGWCr8DNWPOqby2DZG35lxHk0XUlt7LjlilXNxIejzKZIFmkNK9ahZPRsv4+EvvWBMEEsXTWv1uaRK1J4b8zgeTd897wFWtn682dzYnV0f4WeGf4uRVSUCGU4ubrmsBCODPkA7DtW1Uk2RNl/fWJrMjDOaJofkn5p2jPPFz2bOTpsmdVSCw0M7HSkY1lzMVj16N29f1tGFcp0ludKIgvQkZA9QJ6Z5RxNyIXxqyXtK+e6xHOS4Q4m8jKalzSzoiyYcqrFTa8JYhyIC0FqJRLL2wl/2bIneFzUR1KWUQ4qX7sQ1jKLW25QEyTtwjUGoSeePVSUzGKBWZcy6iOWwAUAMqbov1M2gpMiPtP3PW+lF4ex13RByBm21ex8F5cRoFZoWzevYQw3a3i6MOzeI0pBuZxsfouJf8YLyg+ycxvJhdYWRa1wH7sClSsNLMSmlg2EsoKsi5iBCovEz6TTGYpBmv169qAk0SF4LB/e0+zI4LFwnktHkJojTlj+sdy2m6r/TVhjXq38AyvBbcwDzLClBkZ/p5XHlE5/L6l/MvUyeY4Ausr64Nqk5WjdmbWzWq5tqzx3ntZWPME3pYHgtdG8V/ixvaUz1g9R4vCvcDHjvLvhZbn2ot/IQov8hZU+2vCGp5D0wtMwlbKJovL0vDaVhB5AczowH5EPHYL8i+aB0qZFiLfsngwvbBPopurXwXGfFgZgp6IvScEEWfI9UA2/jhSdwSsD7NbIYPAhMVon1vPrS38MvWtab1vFX7xeEU80cJ7FJ8MH67R11vxapXHite2Uth+BRWDXj6LwpVMebC+VlzqPgj1hkSsW/0xnNS1iPa9/UVcfVlPg/fv35+cRFGvf/jwYa8j7F0gxb8TnWllpaWi1Q1skkfAiKlcuEtYOVmhvoXVxZh66cS8pjBaI4x0S5Ztj8c4Epa91XCo4nUWBrkmLIkUKAuezUHleSCdMrJEyb9I2UV98XWw+Rd5XpPL+6CMV+HAk1KTSEb6e1G8GRmq1YFbnTBl5fBSFlSYZgmoUEvkZa3RP89LS118gxO8FpBmSf/QSDqik4xbbwVr8YvvJwo05X1sBb3hU6YEWqEddZ15EWvJP0bPDE49eJdA6Le8rVboz5fdsQZbWipqRHUKmZEx/C1YMTjorX5uhfMSBZsJtTAXXAn8kTwI8s7oZGE03v9eoOOyykp54JeGNRR6Lz8phcQE0DWgN7qB1zKCtzi69co/FMi98m9N7z2Sx+xa1mvbeyr+h+oEVmK7aFVYJxq4DFLXBOWGtlzGCJjllqHFKIzQNxL4o5sK1+oL84onsUQ36/GMwgxLN/3vpbwbWX5bQka5M5pGfL01ZD0LvI/zOQpRqd9qvCOP27eXnZ9Yz6hBE3nMqv8455UuoMe5Y4PYgJ+4RQhZRlx1r9XZSwJz57awulQ/1+p3NtSyFKL6mKUz0g/VhzWss9cGI/0aFVK3RMNMpICFj5SxEc13VBKMZmpet+ZEVKeKFrHv7J4yjLMeOYMzDwQrZ8hjxUpQKcHFyjO3rxdG9oKw/uDvNQQwMq2yVnrCK5HlOypIskLZK9YIT/XsKKyhlFp4XNMLXjKZL9V+FAK5NO0ybTLvtTX2vixTJkowF1BYiENJyr9Wf1Vf8Dv2g5VrtReV36nwgIesVsy4ftlnVUciWHMvCMKo1duyTpjVEIVhsu2PhFouNfmXtHMJHK+hWHrqvrTlnw0PoVFxCTx9m2uMD8M58uRRhqG346FH/qlnlUxQhnyrb6z8TFZhqWd2qrO1gk8++eRIjLr+t4LtB2GhBRXyKk4wFhBmmE9ZZlHnGYh5FpM4DZW5vRmBvATW9CyuAUxJRrTKutKXgkiQrA29RsEILKGvsrDV/VElsiTXtjX/HAXmIXyv5B/e83LOrrEjVUqgNPAek0eloWSwTvSgsC17P1TVAbY/sBzkf6WB7QU58UCQOfGoacY0/ll2jQF7Zh3YJr6PeCoFyf6iurOeQMs6WQP8pi38U9DryazhZa4NvbTcgvZsbqkw0TWVLLNU1W/WH3+Nve1yZLWfwpMZtiP1GGwl/yLo9WBUaMx/x9BXJqxnL5Ni90/OwoqQ9YiaN4IERu22BbOPMQM8k0RLKdc1BHq2H0yQZEMKlwY2gdbghWv1R0HGwmtB5K0bjIYwt1IyKp6uLGH8XpygwtfN9hovDBSvMeOvpWCUcRsZ3CPyL2NU+RBVq+7II0I6tHjPxiDCUap8FlLC1VfKdW25vCf3OhPfY5MDnhmURxmNPwrKuthSGS8FZSHNLo9THF/00ClS2K3ya/Zv1EPptS49ZC377PNLoWVJsxAI4pH5vhRYmAfp0gpNKmXI5qHyGrvkX4JPonBhVF7JaXZNzU9/rToOvo/z1FAgLRdalWkJw5P6ymXelz0KyuLwVkGvkGH1sOtlQfJ+bfAWY+ad+apfWbiF0NISyAr6LTzctWmR8SiVEFahHn+uHtadAX/Ypz8A1D792X4en4zl3eNFLpZ/ifZQAWUjRj30xPr9q61nSKofZd9czo8y8QUUU7fiZi3XL1OePX8NyFgyo5Z1hgZMSV1aWNqhagY+IXgNfBDmzvzTtXBCWINul+5nJuSirns+ZkbIEnqgEvF1ZmUUu6e8LH8/kpUGS+Sf8vDKRoYmcxSwjeM4+kItLcYGI4uwcgl7OhXBGntAGMwkOTbSD2aJZQUwjs2S8MgImMLoeU/6EyL5xm7ZC90KULmMKMBLKu9MW60oBTPGloy9T8a3ciZeiY1Y8dgvH85pCfC15Z+PgKj6lCLrAdZ/vwr35CwsFrNmSJggwQ4wZshoZwbdBM5Kq4H5xgY9ii+26kDX/hYs5gi8O8uA8cn+9wZdWkqnt6KoJrfKZiTMGkFG+KL8QH7HFZ49oMKpLQOn5cVnwon+OipGRZc15F9LQbTkUctYHVVou4eHhx/WWGFd32vnvRtxbB9IHex67yc/+cn+fv3OKmSMqtyh1jlGxgyooEZWZ5zAfEqAFoGa1XUsRWbex60LNP9OALZHxkAJi7WF19K6LmGxbz2mI1bkiJGSCbdGZZRQw/mdEZYeUAYYf5bOvSTKM1LWfl3Oau8DUXvhWF1ROEgBC1uhERrJEBxz1ifLEdn7TaxO2+NhuqDqhir7ra7623B4wAYRQSOUEcIGLyM4sQy6faqOFpH59bnLvchMJrRI1KBlJybr71qTGkG56QitCcfW6y/F7RqQwa1VZo3+jXickUDKPodzO3pGCX7paZL7LLxin17g43LeVnsMmFHjjR7Fu8yCj/oQ9Z0Bk3+FyEEEjFJge8qrQ1wj+mU8JmbQGxw2lH+8++KLL977Rqp3YQ/MhzcRlsYSXqWBswRgdSjQgnFdy9JrcDVpe8NYrI1bhLU2dK1NhxlyBGuG/i6hPEbryXpyqDBaioJ9Z2EcvMfqQvyieiKhXhLzCj1h8wjQ2Mm+zVB5H17WtBQnq1tFY3rlX8toxfuRAcD6gArCNg763CeO59O9w3Hu2BHcam8Mkg0fZRkdtV3GvdtK6LbaZMJKDcgtwBI6tcb40grmNUKGV6IQBbuOxlVkZeJzCD349fI98peSK6rfPZsNVf+ZsmPQChWpZzI4ZeUfKgSGf8bAaI3z7F5djtEncyhOvZPdh10BBPzOQ7+FHeN+IwTz5VtWyyWs88gC8IOmrAZ8dnRCZeASNMkqhmu+H+SlQ88YsjCEspbxWiRU7DoziHrxi0B5QehB2O8Rg8xbx74fvg6lAFq/sQ6FzzXkX2acIuMBaeRTE0xB4Z6aTz/9tObIv7cfRQxPFSckJnd0iTXiX6reQrQkNF/PvbVAh8JO8cfBnCFGzCyBVvigF7ZUHBiDbiXLR8ELNP/XK7Bafz4ZiDyo/i4FvaG6QoycVliiFeZAeuI9vLaU9zCikQld9YB6NTPrk/9ktBmVSVvLv9FIR9Quzg+/stbSFpj/NkVTr33jG98on3/++X/aP/Xxxx/vHzAtUysz78OvbjD3xhRK1OEWEUY6vyYsnRheSKlBuaWQlgfl+vvYNMaRZ7cCzlsqa9CRfVdgbSq8elbprdWHLEQGB9IkK3RQ4GOYQykirAP5OPK4e/vbWmrLkudZwB3SiH9Un1Io7LkIp63lnzKIInzxmjIIsB72tlm/MteuVwXyjW984/1ZCCuyVGqCfTQHwqydlwTITJ5JHgsflFvvK1sOWciEVm52CSYfPuch8u4iYB6FwsvXqf4uARlLPisMFA1Z/yMF0LrGhF/WW0fc/Xef7EZlP7ovhD0XKVXlbbR4tWdObyH/lFHRaiPTT5T9s8t/KKghrGI70f/aX/tr5fd///eP58fUNb8Wzqjhqvfv3x/XP//oRz8qn3322bFBOzd+FquVIkZvMSUO+CTe17ElqAGwc3jq50fT7oR5s31bG7ayqCNlkREsBhmrcC28eutYioOCntBHr/eKirg1Tpm+KgOS8TUaUoj77Bbf4PUlFn8L76ivLbp6WqI8G/EsRuUf61OmPWwDrxng3pkqw6ucr7K/RqRsb0iFer1Gn0zO1/I//dM/vb+3L1HdkXLwMGYIEWDYApHxREaGmp0bjQyIzzGiRQTdGiKLtjVwEWypOLYCNna9/VZx56hPl+p7zxgjZMd81DrshciQySgzxNN/KgNAzXv7nT33aokXxGTSKJ+quZ/15jzOS+QfC2PhGIzKI58rnFye29droStTNlWx2CKrn/qpn3qqp/73sz/7s+Xdu3d7TTNBwsQSKuZtlIP17RHBXaDoSvrPlnsXuZJrTLAsZAZGWfyXVHRbAr59rRUmiqBlcSJsNdZsUiIuWaWg/qI2twQmMFGhYB8Ujmzuzo3cCPNQovsKWl5Qz3PZcqpNVWemL2vJP+bpRXMyY6h5GT5BCsOfwGur4ya3QKXCn/tzf27/uZf8f/bP/tl/953vfKd8+eWXZx3xq3KsI1UTecWBLu7ohLkV5RHhUroE5vaKZO4gS+8xMBgHzfQZvVcUsngERM9fFrJhIyXgMn89gIYG1r8WII0xP6DCvww/Bq05qJRONr+R9YIUnlmvRXlSWCbyulRYbwn0yDj0YJRhhKBojH2x462sHUtj2DEmv/RLv7QvZwrk//yZn/mZ8uMf//jIaOa+1L+qMOpvEwr1e72GSqZlIUQwao1ueQpv637EoE+02AS107Y2bAPX2PcyuAGj1ZJJ15q0WcsQv98qjNKqNR9bXkZJ0FrV6X9nz71awwvy9aLF36NMmNGqvIc1eKiHZ1vPRQY366+tvjXlYLnv+tv0QE1vVP1gUai//Jf/8r8tLoT1f9ekSC3gX1driNTKpsOhWrWiWonfG1LEdvcelzJjFbD7rVN4IwUTDX6Gec5wEbmglwq9HsgZXabr5K1asJYiuxSM8pHysKJyOA97BCTzNE3gFPcSKNwGgM8y3Bl+Ub965Qn2k8myrFGZbRfbV/Uwz8rfy8oqVoeVNe/CjrIyZW1bN8ohR16T7F988UX1QP73Ygrk53/+5//fP/Nn/sxRMdg+EDwHq/6uSqb+VaViDDIfTnA0TYa5kCKUCrpPWQJ0WcKBgomYgk0+tISsjCWWmHu4NFxxaQGHQgChS5hdWDZ7QXAryrtb6ZJro3zEhCLzAqLY/FL+6z33qscLUsZbqy18PuKVrLfDyiyRKeDPDwAAIABJREFUfxmcUOG2PCwPFk2ytqps9yutasiqynQ7ib0u250OJ5L83M/9XPnFX/zFf1f8C6VqSMq0T4HzZgxB01DetWEdz56qiUL31q1BZAKMQ67d1pp19h4/klWsa8JSoT+R+Hi0EfKWjmTJegvZenoEqSq/xliPnHuV9YJQ2ahIRjbK0PIeMvWoMF1W/mXGQeHW8rr8NXbeIXobdWGVbdP4/PPPj55jTXcYHBXIb//2b3/vv//3/358oC7TstyG10zf+973yn/9r/9178b4pJx5K+WwbtgTgxGHTex5jfd9JMH6aX+P7px/fx4YbucvZJe2H4TWBpyXBpe05Ft0a+GihGcUmrgVyHoLLchYyux3FN9fQquec69GvCA2ti1Q9Sk+se/+XeseX/85iYMHVXgrO+atsYp4noHJc4s2/fCHPzymMCaXtqifdd/ff/tv/+3Yxj/4B//gWONxZP/8n//z//ab3/xm+f73v7//XZWAhbFMOUwuI1+vVQ1VPRcfymIEzhDoIiBoykJT8xSvlrHd575Pr1FxZNz8tdpqwSh9R73crcd0K28BrXJfVySIlAXeO/bqRAMPUb9angCDEY8hoj/DgZVXIa6s1xThl6kLx1TJK6zX56zREPabCKuctxVYf/qnf7q/9pf+0l96rse+/Oqv/uq/+Yt/8S+WP/zDPzzuRscGbeVVXe5bXZz6xsIaG7NdjLbhBJNkjGDWAb+Ca6uD/J4REZdZEm6O459+9dOSyabwuTb0hgOW4D5vnLtABd9qA8d9q/FY21uI7mf6zkIxI32P5m907hUackUISfa8Ugq9ypnhgryJodIWjVQYLqMos/1g+Kq2ijtJY4bTRGbIq9i9Wr6eQlJz5b/1W7/1O1bPcaS/853v/Kdf+ZVfKRbGskZMGViSvDZaK6pKpHogVYFY+McI1TpsEa+3NPIWgIyBA+BxzFpt7HcP3JIXw/q9lfeIE7I0chc99aIwKokx8riwUMWasLa3UBwfMWHaElQFhPLomONRGQaYVGdGCutvbzkm7Bko+pdAGaG8yhok6nok/zI8lxkf7KMZ7XUsqvFvp5AU4BMM6Vcn45d/+Zf/rdV7YipUBVLhBz/4wV4JVA/D9nzUTzvGvTZW3RkfK7OGPeNEnVnbau8FpkAiKzga7GvgvzUoobQFKCuLTdIePLCscutb421jvpXyZHire+y5Hv5T4ZqoPhTemTGITt3Fe5GCbyk9pigRlHfC+sr6jcpI8WUWeuSfGq8ejxrLzodjSiz/UeW55a1Zn2u5er/Cr/3ar53UfTKSf/Nv/s1//+1vf3vvhbDG/LKvqmRq46ZETJGYJ9IigrIoMhbSWtAKmSjmzA7crcAtrTbqAWT6EVCC0Y99NJ7KcIgEfw/g8dmj3oL/HXkrzNuL6hoFddouWySjBGpLIUSCndGPeZKM/pkxUDgxUPIvki3ecGHPZsJUWB49SxuLmq7A13dYbtvK/4//8T/2n3/37/7dk7pPFMhv/uZv/s4v//Iv770LW67rXRtLrtTKqwKp98oh1FW9lemwY9EnZJC46BqplVgRwR3JKMEy4HHyL9SayAvkWwOylWV+DfA0QDpcUmF6GvcqbG+hKWGr6mXWqrKMGc49EIUuVBsZb4EJTiagVZhnDQOpN4/JZETGwFPP9xiHDBdfhxoH9R3lgjKWI4OFCX1mZJRA2SgF6p+xpbveObCxQ9n/8z//8+Uf/sN/+F1f58kof/vb3/7DX/zFXzyuvKqaSSkQHzezMJchxjYSRkSLICZ4h+seKJvI8lrqrr4GuFa/W6GNDE6K31BBKcGbCTegwmLKK4vbqLfAgCnB6FmlUC4JPYpZKYkM/sqKR3opZRx5thHerWsR3pHn1fKe1dyxjYJeZvuN5D4lURXIX/gLf+Hf+zbOzIR/9a/+1b+uiuOP/uiP9g/XDSS1spo0r9+twtrQf/gP/2GPRK3YkKiKxBLryl1Fi5/9RQQfAdyRjkQ3IntPCFeFmZbGdeyXtMyvAS1LeQQy9UWKi4UjeoBNqqhOu7b1Pp9Rb0HVVQgdmWBhnsw1oOU5ILS8g+heq5wZxxbCN8DjnvC5SHD3GhU9XrcHfP2GX+lqx7JXmV0XRFVnoPap7vewFbh1NW5VIDWlUd8VVeFf/st/+YfY7pkC+YVf+IX/6+/8nb9zPK6kKo5aaVUK9Vqt3HIeFZm6qbAiVt8pUhVNvW5LgJULmB3EiEB5GJ/sWbewBzfGUBnGujZcGr8WXUetfmxjglwICtWWMFiLLku8BXWP1Z8pi89t1dfoWtReJgyk+KfXOLUVpj636631SOCzMFRLnijo9RrxcNsZziezlwPaC6Sq3K4Kpf5VeV8VR11lWxVJeTo8sSbQ/xds/0yB1HOx/sk/+Sd7ZWEujGni4pbh1cpro9VTqWW/9a1vHY95r0h4jec7MrrTfNyt7rBmpnOmWtP6HlGcLwVeghJE8IJRjXHLM1kKzMMojj8y3kIGWsKuBSqiMAJZBanKRUJYlRsV1D5E1Et3P16jc6OnDqUc8bUK5bBRvOaxqwKxFISdxGG7z+u1evJIhd/6rd8qf/2v//X/Ddukma7vfve7/6Z6FH/wB39wPCOrNliVRq3Yzsyq96ry+OM//uN9o/X4E79zXb0vBAdZxegiAq0FJ0Sf84mvKLyiIIqr3iLgce6vGSKr+BrhyqxnwWBtRY77OHpw8dDyCCIZELWHgnOJMcPC2vbHBDEDZpQo/CP5F9GgFR4zZe89Jx+Grd6HT6Cjp1IViy3dre+K+s3f/M33DH+qQP7KX/kr/+tv/MZvlN/93d89IuaX7B4f3u32q6+qF1JXbtUj4StSvgwjBCOiF66XFFqqPRQaKPyPnx2osrZWy/FssGLmFs71WktQXRqHqK4RHujBwbfBrOde+hh/tE7WHYWZJIJHlCWGiiJDVb2jBJf1qhC88ghYX1oKh8kXvB49Uwi9/Nl+vrwd227Hkvi9IBbKst916W6Fv/W3/lb523/7b//PDA8qOepqrN/+7d/eH5hYcxy2idB2LValYVC/V1eoKpGKYPVQTIGw5bwtV/AaFm9mQqkyu44QGatny7hySe4BUWWu6YGw+LEqh/eXhAwiGLVsz3Cftw/5obEy6kVN7nRtxSeZPAorlwnJKWu8kD4yxawEspdNUTQB22e76JmiQmgZqQzHXkAlOcFy/HrdEucWqrIIk0WNqqy3PSE1/13r+O53v1v+6l/9q/8HQ0cu1v6n//Sf/srf+3t/b68YakXzYVVSbQhP1LRcSN2AWN+vbll+c4c8QTY962oDYAyxZJCxnmKCieRfltaL4PuRGYdLeCARrpmwJrMG/aRfE//R8TkzGsrpHoM1cVQh2NG2kGdaZRi0lH+m7QkSwlH7S0KOUX4lizMqljX637qOisOOnvJHUNX5XGV59T78vQlewTEdDsyt8Ou//uvlH/2jf/TPFY5Sgvzsz/7s/1cVSD3mtzZo2Xrb1u4P4qqeSvVCqgKpZ8UrZs0K3muHTQxawm3E5cZ67NnqySyJ27ZCFGryoSLBmO/WoPq8JKTRChONjNW1PLFeYHxg83ENwyezybYFrfyBr4uNm/9UISysi8mjTLh8JvkPtjUBv0d1R14V6wcCU3IY3THvwl5PWw4n61Y5XpWIHYxrfxbKKgcvpMr8Ktf/xt/4GzR5bhBywz/+x//4n9clvf/xP/7H42DZ8l6/c9HWEddG/8t/+S91KfAxjmabD2sC3uJv7Cwcn/RZQ3DNkADDP/8eEBb3LKAolHscxUMzsEW4hbnpxU3IjAd4bSWe9UAKmUCRAsXvPYppDQW/lXek2i1JQame9ZAVnAbKyx0NYUfGRiFzKQpN+Tpb3u3kVpMWlwtCxeIVTKQ8WNi1NBSH4mk80cMURlUUtmfP3mduiXNTKPV33Z5RFz/ZEt76nL37o8rsf/Ev/oX0PkpLgVTN8/f//t/fZ+F/7/d+b49QTZRXr6R2suY/aiP1s24yrIqkJl4q0nVZr7lOtnPdd+hWoBU3LcBkOClHFcBSizgCwwdXzKAFde0zspjntMT78ePExiQz1msBWoQFri31BjLPowfSA8bffjOtX8pfDidTeMOvCJ7ydbA/xJf1oRA+LmJMWf+VERjRMfJkIyUQRQOU0mgZoiyEZ+NjcnY6nEVo8tXqrNdsVdV8eP14VSRVefzJn/zJcZN4cQujKvzO7/xO9UCk91FaCqTCP/tn/+xf///tXV2sXVW1nuvwcx+KEVHkt7aA/Ck0hQMkXg0oqWgoSa8VUXtVJCp9QA0lklsC8mBjAjFoUF7kBR4kmjRG0XguzTXBqMGElKoUsIBt0UIaXoRAm+t92fvmW93f8TuDMcace+/TH7x3JCdn77XnmmvOueYc3/ibY0KNQaguHoZ88GwEE27hP9QdfMaBVAARoBrAhunfGcU1iTSktNgLfly1tiYVZxMkek4kEWfPspKsp8ZGadC5aDHxdMF7E9RrV8T0h2Ynf0YKvpPOB0+jUgnQGw8Fp5qpwPbRap3TUJTEr3V+R+2w7yljSDZIgnXqWuX9Nj0RpV1L9prdO2IBxn73xsGOUW19euWydRjVYT+3UKQFRRQBUsRbrAajiWw5nno6LM1WTEvFe/SccxLPdYKCgI2E69evv6XW5SqAzM7O3v3Rj350fks7zFQAETZC86XgGhqAcugoAARohns44ZjuxL6wcV7QtBRJHbWXF12LVGjSoCw0gynztBM7k6CztkVahr23GznM6MMiiGh6mfl2O+ASPUOZeWv01qESJjxwba2ntsCz9kdSqtVcraRcm39Rm2qAYcsrkOp99jyfrC3FmKq8zYb6m2b11nmopGDtrRtSthZqmgOfm2kf9vm2jdlYj0M1oTSqe2gOg+LvM3IUOXeb81AolkG0LK4TRPAu8DuUBJS98cYbkZ39O7VuNIVDXXPNNZ95//vf3wPBCy+80D+Uk4KefNrWNKwXYAIQgTmL/hCYvBZzwCch+/JbmECreu3dTwd5NlGihZJNVCsVZ+3Xe3TxeG2KGF9WrkWCGrftNRpn3iiznuS+1t/tuysJQESgm42nBzwleM9abmCOLbVamLbBMilPS+A1AkKkWXgaCedftK+kZf55YOtpc9H7I4hNCgQesCyW1mKf7QGsCnEKIOTBuB8AwbPOu9HGb4btwmSF66wDPBzf8dt73vOectNNN/1rS9ubAOS88857aO3atS+fccYZvSkLjaIzHKYrNHg4MmWhYUA3RGQBRHDO+tKlS+e9/CgDm9s0NA4DyDQHkmWmLRJdMYvbLmZPu/AYiFe+mEXitSWSjEiebZn3WPNJcc6xtswskgL1OhkQQwNr5oGWfhwMal3cGVP2ftdyHhMcimnFG1cdRw/gI6l6nPlXBAC0PbZtRd6NDdvvnEAM/W6d5womFjSygA6PcWZlI63FlmsVHqP21ADHA7fo+d69GZgUs2bsWuYapHUIf0PJmM576cdmeQj70D5gabr99ttfXrp06e9axqR5Q8bVV199/po1a3rfBlKckGhvo1aCP5i40FioTwAcAAc0EWgfAA863MoYi1nLj3NP9BJrwFJTYb26vBdvJcdMk6lJVfYerU/b67VP7+ciphNUGUoZ2UI9RqIMJRo3NX944+JJ6JPQpKAzCcOIFrXXLzveizn/lMl7dXkCgdU2bJSjvnePmVvtRe+LzFW2/gg0VFjx5nzEhCMBxgNDb53Y8coExdrzvbIWsO29kXZRWw9eX2zGcKZhh7WI2y2glQxHZ38wqAm/MzIW9cB3DcIG8nXr1p2cNkSoGUCOP/74V1atWnU/QnSRYIs2Npir0FCmAkYH8BlIhob/9a9/7Xezn3jiib22Age7pjoZlxEslsQaMWRPeqtNrkxSiqTGrA3efbZcJL3yv6dJFGEIXl8tM+nM+fY2rXUEDN6Z+B4DnuY91iS57J5xn5sBc1beMrro3UdML+tnaZx/xfFBFAMsXp9q46hMy9NGrInL85FoW6J+2LGx5aM5YIUfjzzA9uryPnvtzcauRZDw1mqtbxqFVUYCPbQPaBiDUdJbah4cd0bO4h6eLAseDt6+du3aX7/hoQl140qBP/rRj/asX7/+dCRbvOyyy/pOAhRgqkLDeHbIfMNnuj51A8qj0dBKAEBERSvdZu3JpP0DadvrDjaVsjN6w16V7kCyRZJGqnj1e8/WttXK9cy8Kws2GLZKTt0odM9bvN7n4tisOT5WomYbMFFrDDT6XoyDnotgIKmza47cGrVIcxF1ZmduRrXF7gkTLWsu03g8TceWyfZsePd6bfTmG79z/kdtLQF4tM4/m2rEa4OOQ3bNGz9vrNUvktVpx8fSYpa1vIK/gb8CJLBOwFu70bGzMEOhH+C1unWiyJrGb7gP93MDOK7dcccd+BtLuho7p8hVV131vg0bNvQggU2DaDg0CwICGoXd6EcfMzozpFvYeIAKNBS+LEVPOoMiBM8lx1jS1zqKoHgmmVjVspP8RdkCjAiRWDXVtsiEiRavd5+VtrRdkaMyCsG0kVeRVGUlZe+3jDxAWQzNcjGoBu4twsC086+Yd2vrGXf+2edHTH/c+Wf7Y8tFPo5x5l9tjtk2ZmDB37zNzNm4RGA96fy39dvvGq0Gfsm9GZqnitnRcU2zheAaTVfafh6OhfLg03A7MGEiIm0/8YlPXNfUaKGxAeSEE0548dOf/vR1Z599dtm5c2fv40DnGM4L+vvf/7scc/Qx89kdO3Hc4hoQUx2tfKGUOj3tYNwFU9NkatLX0OxpiEJau0abfpR00TJ9nVC4x9adMQFbB9uvpgZ1lnsbCq1ZIaOMwY1Dw8BGfbjJk1Ttu8qk0Mhs0TL/isPMvee1zr+IsvkXtckr5z3b+kjs/NNyWsbW5/Xbewe2jba8jmOkYVoekNG08z9rL10B4J/QEpi/isI3PjPaCr8BCDQStoxMyeC3BA6e4cSD/2i+eu9734sd5w+de+65m5saLjRRVkM86Otf//qv4ed49tln+2twnKOBCNktErbaidP1ADPr+nIAkZlRXi2aQ5i7RTfCKE2zUDxawIy7Nzq09A8axMBJezIYnXjopXXXBInKfLznFAMKC5hI90anak3q9ezT1mxQqPWVf5j1bApoT32ujanHlCJVvMXEcKgpYqKl+HNEf8/uzZigrdsrNzS+keg5es3OP++z9870v/6mn7O5UZt/1lTlhQPX5l+kXUTak7bZAlUGzNkYW2qd/1qft54xDgirpSOc48PNgIh2xWeYn7h3g0ChAjkF+BnJicVEicguguPIb7755nLllVd+pto5h6oAsn///mPxZ69fc801V6xbt67Pm7J169b5FMHq9edg8vjbA5L8gYECSkKFYgdVyq8tqEkZTLTIhiMTlb0eSRgLJMLhaKOgd//Q70M2Wd2JO/SZSMacimMS0O8LJrRJL+45V73PHkVtsv3S7wNzfvPhAhAP7KMySpFWaBla9MzoOZF2YRlPxJxqmo73PZL2a/PPo5aQXRva65lcvfnXMkeytZuVyeb4pPO/9iwPgGmWQuQrhHU6u6GFwIQFrQN8FzwUPmi4EjQEnAK5WnuY8wrWIwjy4OFf/OIXJ15wR9cKLFmyxD2JCrRp06Zu9+7dw4ceeqicdNJJ/QYUIKNuXoH0fPRRC7fa8zMBBIPBjpWRn8Qb1EnIk6pKsHDTxdx/WHitB46RqYkpuq3mYLPsKlPJpMmofcWRDkneZIwWsWV6HoOvMT9LLeVbTCDRezhcFAFE1Df97r3nSEDKylqK3pU3N6J2RWMf9bVl/nmMMAvhtY52r08e1eZ+dl8RocV7jqep2d9a2uTdF2nhti8YD4IGNIwiWyVwDa4DXoP1B/9huQHAaIAPtQ5cA0/mZsEy8nusX7/+38IONdDUB3PcdtttN+AM9T179pRdu3b1DQSA0NN/VPePcFA6zImS3HgI5KRzx4stn4YiQGiRDGfMue66U7d/ySXXlPi7BwitEne0SCLpyl7PzAZDk1hx6KQnsf2LGE9pZPxsYxTCeTg1kFaNw2oHXrmIeeuzav20zFDrHFcr1HdjP9dAw/Ylm3+WovlnP+s85G/jal/etaifOv8ywTEbX+8ZLYJPy3sHLwQogI9CwAZP5fhA80AZAAcClqh56NkfuvGTvmUFEOz3+PKXv7z57LPPfrja4KytiyHpPfPMM59fs2bNA7t378aGw75jjA5g/Xp4STfa+QgVqhvtmuS5I/iMQWJ2yEjKqbW79lKzMN4WJsb7bf21SedJiTXzQ9T/BXV1Cx31NozX/qctNaNIurRA45Xx7vE0Ix1HAnRU/zhUe/+ZYJGVqZE3H6J3FlHnOHkzjcGbf9H8zuZScd5ZdI+GcUdg6Pk/7H/7O0nDhL12ec/zxrkmBBUHCLz6W7Xr1jZH2g+J2gRABH5lfH/55Zd78AAfxcF9MG0RYLCe6f+AWWtoXAIog+0T4LG4vmXLlvs+8IEPpKnaW2hRAAT0hz/8YcO6deu+/ac//anceuut/W51xvbTrIWOoONw3sBmx4Wiew7QQcY3s202QksPPplxErkNRsc1eqQLwJJl7tFEKgFQ2Mliv+u93j4S7jXxFrCdcJGjmxTZnt8QTYZnOhFi0SYzff6Mk821mMUSMSM68iJSYLESf8vingaAPAZezFhnUnsxfh2vnOcP8ABs0vmnABJJ/JmPYsakLrHvn+un5r+w9ba+F6+freDgCV8eA5+EWsEJ87szR8pq27hnTo+S7SRaFYBAPzHKYTM2eCP4JtwF+IMZC/cz6opOdmorfBbAA5oH8hieddZZ5d577/3l6tWrPzzRABhaNAABPfzww1vvueee2d/85jdl9erVPXKiw+gAmTo6CA2Fzh8CAweQCcAQXaAAYRfSUUfN9A55u3ua9dDON6kEqr6abIyiyZQBSDELqUXDsOUUAL0NW8VhUl4Z2+biAIHHyCiBemPkSV62jhojUQCx4xlJn/qbB9DFYTAR1aRNb9OZtsMyjex+2zb9Xiacf9H4Rv6GjDxNhO8nMkuVKeafXs+kdHt/7bdxASR7rr0/6kNxzuUBgc+RX9HZjTFh6nWAAjPmIqcg+BlA4/TTT+8jWAEePNeDznWUxTMAOvRDs44nn3yyv+8b3/hG2bBhw6LZiKtO9HFozZo1l5RStv75z3+e/ctf/tIPKjrAHFj4zmy9ahfVnPb8DrTl4Sj0p3Qj0xfqogajk3QYpGfIKGLWJWGsHs0zXdmxbkEoY2aZJG+Zs6WByWeVLTZdxK1MdKaS+tr2xaujxqSiZ3v3trwHb9FqfRagWph01IYITIrzDm25GZM4kUBpU3RnbbQSt4JIZEayCS/tMxQgPId3tEHQ02y832v9UYqAOtNyW8bOezde/d53r//eO7brX5/HaxQG+V4odMOnDD6IPILnnXdeOfnkk/v7KZCjLPghhHGAEPgsBTuAxrve9a4+ldRTTz3Vg8edd965qOBRFlsDIT3yyCO/+OQnP3k1NA2caIjGMzfW9u3beySljZ5axlDSjHOgEX2AJF8YxCI5XPQgpE7MG0PZYVqTcKO9JiQyBS9ENyIt3yKFtzItb5JbDcs+K1rg2r8STPqhcUJ6ZgC9TxmCfS/aV73XJtS0jDfS0FrGrnipaMbUgKLxJamJValVi6gBqvUxtJD3bqIx8IStYjSKGhMtgfZbm3ulMv/0eSXpV8b4ByazgTd3s35F91ngj56P+TMzSlzIACEKxPiD8xuCNLUNmPkZcYXrBAicBgutA7yUpijWTzABgKAOPIvPYRqTxx9//A2aB7ZlZNG149BBARDQo48++sC11177eZiivvCFL8x7/y+++OLeFjccDub3hOjAd6OILR6RC1UMzh9uluH2fUQe0IaoWWU7E+UTEQHEm1QqoZaEKXj3AUDgzI5MFPYe7xmRxKoTmGmao0XiSYGek3IofhB9Zg1gi5HyFXj0PUTg2VK/UqYBkDxNYVLiaZtad5ExxsLPnm2dwNruzjHHWWZk559Xxo6FvZ7NPw2iiCTxDIC88Fvvu1LmJPf60cLYa2Pitd373Xt+RhGwkOjjoyDAnePcugB+pgI0+CMc5AQIaA/Lli3rAQQCNPbbcVMh1yefywSKrAuggnt+//vf926Eb33rW/N7PV555ZWT3va2t71c7WAjHTQAAW3fvv3Gyy+//PvQInC+LpGWE4vpTzQfltoFCQwECiAz6gLiIgKB5i6VfljWnnpoJ1tNAvUkYGoXHqOyzFKvR1qMtwiiOoqZ4OMweGtWYCy5JX2OTZYYgZW3cFulUNunrMy481QDMzzyzCg67np9HA1SgTTS3KyAUhxHs5cW32tLTdCI2hrNHyuETaJd2LJZ2G5tnkeCW0bZXLHjFmkR3jX9XkvGOhztwWBSWZ5LDoEYzB4CMPkVroPho9xpp51Wli9f3vM3vYfvaygHQDEwCZ/p/0Dd8I8888wz/S7zu++++5XPfvazJ7Bdr7766knHH3/8mwNAQM8///yaD37wgz9FCNqnPvWpfgBgwgJK8pB35mgZSKoQDDCAAohcRuYr/AYQwR+iEnCNf0B22nWLmCAiqvXbMhD1bWQTnZ9nzFGddjFYu3n2vxgGUUYMIAuL9EjLWB+A1/ds8SrA2IWWSY5KWRkL8hZEavXXADYac5I1gRQzHjUA0rGJzCfevRFQeXXXNNaoTDEHiEXzKKs3ChPPaJz51woe0Zh5QTDR75NQTQDtJMKUY8XcgDwVEJGq0ETg8wBw4MgLmLZgrsJ1aCT0AYPAD7uRkxzzm1Yd1IdnAYTAZyFkI9p106ZN29euXbti4k420KIByL59+4497rjjXLvaiy+++L6Pf/zjj8Eed9VVVxUkYsSA0gyAAQEI4DsGhQ5E2pk13I3HMkKlw4Bi0HRg8TLwP5PGisNgvAVmU7h7FJlNLIDY50QTXNuTIbYhAAAONUlEQVRLc1gmJWfSaBQNU8TGXQxD0vqs1qL3qgmCEquNiMvMCxnQDI0vywKa/h7VUWMOtYSdndl857Uxo9rzpwVAr81ZG6N5UoL5VwM61TQj8MhAJfOxRABoy3ltt22092od2fzLnl9G+9psCLR+twBDbYLmJgjQqAPC9Lvf/e6e4UOg5l64bpQCipFZnPMEDlyDNYfPxX0IXELEFu578MEHnxgFNR1UOugaCGnv3r0X3nrrrU8i7QlUK4T5wr4HtIQ2QeTFdwwuQ30ts+Fg4XcMIkGEaMz+MMU8wMbm3Bqa3aoDkyCR4GVJJ2kEEKTaRsUSTNQi0kt2v7fQtW5duF65FidyFJDghWtaoLEMMGpvRHZx2/5wcVHY0CwGep83vsU59MoShZdICKHwE72/6LnRdf3dMj/vs851r17rw+EYsS8Q2LL5Z08uVIoiu4ojrNQ0oUh4idrGe+gD8MbIowg8o+eTiet6GjpacGcOXWN5bu6jmZ7f4b+FeQoRVQANOLjJx7pR/iryDv7n/g5aVTD3wdNooYEp6+mnn+6F6o985CPlu9/97nXnnHPO2Jl1J6FDBiCk++67b/jNb36zHwBoIuecc07/GcCBASJjwEux5/pydzpUO6h1jGogeLA8ytJJRRMXytMmqVFfxWxIpORd2+g2LdUYeKa9FPEfKak0aBeSXTwaLVUcSUujkIoDdt5n/U0XnsdkauPr1avMaWY+OefC9PRc5DyFzaurNIx/JDln60WfkwVhZPWT7D4W+55q91tN1WpxNQ3H+hBtnZHwwjGw89MDmcy/YoUA+yz1CbRoMdF6iMroGtL1wjnGPRj6N5A0TDCzU9ABzwFoQGBGSC6TIc5bWIaD8i/HHOBTWHfgXSjDaCymKgGfU/8H+CFCdJERHQI4wnS/+tWvTm6Xm4AOOYCANm/evPOuu+46E4gJh9GKFStGKI3NhQfseRhMRl7xfHUMIPPdaxTMcOT0BVPCC+ABK5qevJNUGdylPiPnCdvMlR6DycxH2hb9HEndmQbhqd+2XObj8RZM1s6oXZGK30I1Bm0pkky1rfq7mrD0ugXG6DneiYsRI/La5PkJlGo+OGVQESOzZpFxzUQkTxtuAVDvHdj5GVFt/kX18jOlek/btmPuAZF3YqbWY31Ytn4Gmigv0H7T1K6amkZVETQQBQUAgKaB/8PRzvCh2bZQjFAE3gc+h3vAm+hoR7/oNP/jH//YZ/WYnZ0tX/nKV/Z/7nOfOy59KQeBDguAgHbu3Hn1Pffc84sf//jH/QCtXLmynHnmmf1vMGlxAlMVp0kFLwzIPDTnMtPGSC0Eg4z/jJ2m/ZFg4vlA+BufG014CzAeE7Fhklq2NJwbHqnc/M1jALpIrY8l64tHNcmuBi61KBU1EWXP96RoOx6152dAEAGA1x57b3Sfx/S83y1ZsIiEh9KQaiZK5dNKmQbrPb844Febf5OQajhR+5RveG3vTISZB9IEoGjtdrL/jCG6aumAQ5wnCdIERcBhokQ61fEMnv3BQ6PKaA5DcKZlhrvKYYF59NFH+/s+9rGPIdJq9VlnnTW3KAM8Jh02AAHt27/v2Pu/f///PPjggz2SQg1DrhbEP+NFwqxVRmeH0FxFhzoZNBkLN8+wDCeZ1UwIIrQh4zOv0fyFz5EJhOPlRa8otZy5ni0qq+lYygAh03hs/dEij0AiAhZbb42B6T4cu9C9Z1otxLbV1hX5OFjGa58F4IwsY7FjXtMKautOGaSnocxI4knv+WBmxZknLF9Lphm9v0wDidaC7UNJ5l+kjdl6dCd9BrS27bbeaL1Yv4aauWkF4RYCmqm0DPepab8QFANTFY+ctZoL+dVgdKY5hF98J9hgT91zzz3X71DH5sL169eXG264YcUpp5yyPe34QaTDCiCkbdu2/ccPfvCDu37yk5/0MczQROAfwYuB6ocBxeBh0vNFcYEpsNAPomolgYFAoj6VIrZzvjgFkBotpmRVHEZRk2KzOmoaUq3d0/ardv+4867W/nHbSwYRRRJFGwG1PRmjyxzL1k+VaVZRGY8BFwPCHsjaeyJhIJtftj3euGRRch7Tt2CoIfnes/S8b480FYwdT69N3hrRceTeNKZdogWE4KGp1FkX+A3uYdZc8Cb6/uC/0LYQeMCHaJ6nRgNBGrmsABzYYAiT1caNGzdddtlld4YDcIjoiAAQ0s9+9rPHvve9773vV7/6VT/w8I3ARwI1DgOLkDcQBhIvhYySwKCaBhewaiz4nQeuqP2Rf+qYy6JUWmhaCdTbJ0KKFp+9nxQxsOheS5nJymOkw+HCJJfefeM+P6onopoPwpoxSGrv9sbZ60MtXNXbRFdzJNMEE/W5piF5viAFlZqJp6ah1N4ZNSCv/haaMfnX7Fho/ihvfLl3IqJM2y2S6aHIXCFQMD1JNzIVcmsBNRMFA/pzKZCSR+E7hGPmswJosC62A36QvXv39vwO2TguuOCC8rWvfW3/9ddff8h9HREddADZt+/1Jccd95b9/P76668vectb/vHd0gsvvLDq5z//+X/de++9/bGLUPcuueSSHkh4qtZAzgYuo4lDcKBzq4ivQE1XurudvyvTsCF06eBVzEiZqadUpOrMGTwM9kFYhpAxQZXASxAt1QIaXt0lSAWi35XBZ4xSr6tZQcOoPW2tBrIqKU5LrRqellMAyASVyFRa89GpidCLbhonCq2mQXhjXTMvZRpIy3PoJ7B1kFQYLAFI1mhoHNzUNnAvgML+TiDBZ5qdaPHANbSZm/5AAJByIDdVX4YOc/yOsFykfAJwYJPh9ddfX770pS99ePny5b+sNvwQ0hGlgSg9/fTTn9+yZcsDP/zhD8sTTzzRv5AzzjijLF26tB942Ac1QRlzYvGlEki6kUONm3eGoxBPRDSQIeE3SAAaWqoSlEctJpqsTGc26pE0KCCqq2Y+aSGq4VHbhmajWDESd4uPIDMh8PlRvyIGq+NUG4dMA9L+R8wuA+eWKDMPzHh/bX5lAkymyah5LGPemslAifXVADYzURXz/qwmzbmfvX8bhWU/636JoQTUWIEwq8OLrrIgyLZq2nWN1iSQs5wCiAqB1FY4rkwI2402QDM/FoRmZNAFfzr33HPL2rVry7XXXrvx4osvvjucEIeRjlgAIeG0w7m5uQfm5ub6sDXmuEd6Y6qqTGOM6CwmI8N1NWt1o81RTH/MFzwwm8+ounJiRBJMy07hmobiXdfvB5OyBTw0Gyk9LaWmoXlOWH0WgxhqGpYdm5bP3nha0v55kql34t64z4jIjq8Sx9pLtx4BcnGYZdbm0hAEohtv9VkZKCvV5q83/7SN6oP05h/Xs2eGjPqnZWw2ZTt+Kox68wMbmRVI6AOhc51Ro6q5aJ9QlnvesHv8+eef79OQcJPhxo0b919wwQWbZmdnj0jgIB3xAELatWvX1XNzc7945JFHevUOKI3BhzaCiASkix+OHFfDUdjvQA5owctiIkdu4qHDShe0pk3JyJpoSuKcLI4UpuRJwjZb8LhUU9etZmEZiQWAzEzjMTlvo5d+bnl+K/Pyxi+71+uHva+2LjIJ3xsjW67WztpO+WmpJp3XfHjjzMuorDc3+F8ZfGbu6kZ+UJ0/6oCP+hitD362Y6ERVviDEEqfCMFW5zaEXDU38o+p3aFh7Nmzp08/gnKIQIVzHBk6Lr/88ltWrlz5nenf8sGnNw2AkF566aXZHTt2bNiyZcu/79ixo2zdurV3NJHgaMfLYEw1zVnULOiwQs6sgRynW8QHMkiOxCV5+yys+lsmAADWNXDSwU9D0SKK+uAxMAuMmTRubeh2wdac3DXqkvNGsnHV7xlFErzte/bcrI6aCWxSwYFkw1AtM7YnCmq7MhNY65y09dr7vDrHATC2UzffKfhYiuanvcZyPJLWCj0cG6ZKYhmaBPFsPh+AQY0EvyOaCrwKfg3UDx50/vnnlw996EPlyiuvfPiiiy665cQTT9xVHdwjiN50AKL02muvLfntb3/707m5uVWPPfZY2b179/zeERKkBLwoZvMlkHCzIaUWhgBzPLwojpo5QcmTZDKGVAJmZJmQB1Ze+2p1T2qa4L2eD8Hrf0QK3FnIq5JKmdNulGsF6KhMjcFlVNNYLLiXChP32jitBhNpBvo/m8vWx2U/R+edKLO2ZM1RCiAU/PSAumysVICxwRlKdlw1Sg73aZ69IiCD+2BSB1jgP56HsnSur1q1qlxxxRXQOC457bTTnpj4RR1melMDiBI0k507d964bdu2G2HiAqDAtoh0KUMnbUAZTSa+fNo8GUoHFbUkTJkMzC4Mlm2RoEjeZK/t1M4ouq+2QJVqPo5au2oaBhbSNPVPS5EZazGfnwFUi/aU3Tvtup22f7Xn17SASdtvtQyOhQogup6jflozVzFjomHoRda0/md7aNWgOVzbCZ/GqaeeWi688MJy6aWXIqL0/uXLlz+0bNmyX080AEcYHfEAghO0BoPBMW9/+9tfHPdeHGi1bdu2bz/11FNLEN0Ae+NLL73Up0opDpOMzBKLMfH/r5GnSdkx/n/656ZpTGA18oQ2O9cOBkXzFz4P5L2C+RwWD5y8iq0HK1eu3LxixYo73/nOd+5obc7+/fuOXbLEPxrjSKN/Gg2khXBmyWuvvXbh3/72t15b2bt37yxsklQx8YeYbHznOewRtUpwkRQUaQAsP62PoEY2Csma12phtLX+Zzb+yExXu1/buJiaWUsbvbqmoWlTpdSopmHW5l/t2jg+nHH9U6VhfDUScCg71wfOOSNe21RTsJ87ifBi+C40Zpi18cdryKyLbQXLli373amnnvqf73jHO3731re+dfukR8ZmZyodkVRK+V9DrqeMFczn4QAAAABJRU5ErkJggg==");
      background-repeat:no-repeat;
      background-size:cover;
      max-width: 540px;
      margin:0 auto;
      position: relative;
      height:100vh;
    }
    .mob_inner_con{
      padding: 35px;
    }
    .btn_click{
      background: none;
      border: none;
    }
    .btn_click:active {
      transform: translateY(2px);
    }
    #content-wrap {
      padding-bottom: 2.5rem; 
    }

    #footer {
      position: absolute;
      bottom: 2%;
      width: 100%;
    }

  </style>
  <script>
var gateway = `ws://${window.location.hostname}/ws`;
  var websocket;
  window.addEventListener('load', onLoad);
  function initWebSocket() {
    console.log('Trying to open a WebSocket connection...');
    websocket = new WebSocket(gateway);
    websocket.onopen    = onOpen;
    websocket.onclose   = onClose;
  }
  function onOpen(event) {
    console.log('Connection opened');
  }
  function onClose(event) {
    console.log('Connection closed');
    setTimeout(initWebSocket, 2000);
  }
  function onLoad(event) {
    initWebSocket();
    initButton();
  }
  function initButton() {
    document.getElementById('pwr_button').addEventListener('click', pwr_function);
    document.getElementById('up_button').addEventListener('click', up_function);
    document.getElementById('down_button').addEventListener('click', down_function);
    document.getElementById('left_button').addEventListener('click', left_function);
    document.getElementById('ok_button').addEventListener('click', ok_function);
    document.getElementById('right_button').addEventListener('click', right_function);
    document.getElementById('plus_button').addEventListener('click', plus_function);
    document.getElementById('minus_button').addEventListener('click', minus_function);
    document.getElementById('next_button').addEventListener('click', next_function);
    document.getElementById('prev_button').addEventListener('click', prev_function);
  }
  function pwr_function(){
    websocket.send('pwrbtn');
  }
  function up_function(){
    websocket.send('upbtn');
  }
  function down_function(){
    websocket.send('downbtn');
  }
  function left_function(){
    websocket.send('leftbtn');
  }
  function ok_function(){
    websocket.send('okbtn');
  }
  function right_function(){
    websocket.send('rightbtn');
  }
  function plus_function(){
    websocket.send('plusbtn');
  }
  function minus_function(){
    websocket.send('minusbtn');
  }
  function next_function(){
    websocket.send('nextbtn');
  }
  function prev_function(){
    websocket.send('prevbtn');
  }
</script>
</head>
<body>
  <div id="bg_mob">
    <div class="mob_inner_con" id="content-wrap">
      <div class="innercontainer" style="margin-top: 5%;margin-bottom: 6%;">
                <button type="button" id="pwr_button" class="btn_click" onClick="" ><img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABwCAYAAADsUAXkAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0UmVmPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VSZWYjIiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDpDM0QzQUMxRkUxNzExMUVDOTlGNkVGREQxMDU1NDkyNyIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDpDM0QzQUMyMEUxNzExMUVDOTlGNkVGREQxMDU1NDkyNyI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOkMzRDNBQzFERTE3MTExRUM5OUY2RUZERDEwNTU0OTI3IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOkMzRDNBQzFFRTE3MTExRUM5OUY2RUZERDEwNTU0OTI3Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8+8ECzSgAACdJJREFUeNrsXX2IVVUQH5+2SSUqtYbFIpuY+NFitiwRZWGipVlpiWhZWSIVJn1RGUX2nRZR0vZF35YWYqaZVkYtYSYmJmqKmtQiYRJlWlmZtc3PN0+ub9/nnTn33fvu/cH8s957POf+3pmZM2fOnA5tbW0UYZzIMpKliaWr/G0vy2qWZSw/RXVgHSJMzO0sV7AMyvPva1kWsMxOiAkGnVjeYzmVpU+RZ7ezbGO5lOVgQoxbzGOZUOY7i1jGRmmQqYiRcjPLmT7ewzt3JMS4wxiWeh/v9WS5RNRgQowxhosX5hdnsYxIiLHHKSx9lW30SoixRw+jdU9CTIJ4ENMxTuNNZkxCTIKEmISYpK/JYJMZkyAMCDp2NI7SMas6lr9YVrA8yfJfCL/NjdJX/Hix4Taf5f1qI2Ywy0yWBjoyLDJcBj+Wiu82BkXecSwfSJTAGwLCLukkljksK6NOTA3LLEoHD/vleeZsludYLg/JTHmFZUiOv/cWaZCZPoPl9yjaGAzuI0rvofQr8uxA+UVWGoOlL4WAWTRNyLkwasRglrzIcl6Jz2OwA0JAzIASfkQZYPOtmeXhKBCDDamlLJdR+SH6o0JAzNFlPl8vY4VmqA0rMY0sH7KMEl0cF/QVJ+ZjUYWhImY0y8tiGOMKpFG9amV3LIiZwvJ0lZDyr/L9BvEwJ1WamOtZ7iZ/CRLlrlOCiFJYrJWwTruXZWqliBkvrnA9JcgGEhFvlW8UKDHwRO4jfXJE2GAZXegr32h0UMRgAfZoGf5+nIFv9Djlz682IwYZ9fOpeM5wudjAsrjIM/8E8CHh7m9y4E7PZTneJTEvlBCyKBc7hewwHJlAH15naTVud6B8OyfE3COLSEsgG/95lsdCpH6eYHmWZYtxu4gF3m9NDOJCVxqv6FeKS/lICG3DbFmfrTJss068tCZLYh409MAyqut8lpYQG26Qco6s5q1UW19xnEyIwfQ72ZAUDHQiy4GIuM/XirrdYdQmvuVdWmLg7o0zco1bRX/fF0G3FzbwSSNyMGsmFPNsixEzw4iU71geovS2bFQBh+BhI3e6odgPtBAx51HuLVa/M+UlZTsdQ0AO1HCzeJNawKEa5ocYBCi150m2yrrg2SpazcPevGGg1npTgUBnqoDPbbFmWRNRm1IMUMtrDdoZnM99zkfMjQZrFpByE1UvbqB0oQftrJleKjG9yd/J4GxjP5PSVSqqFXtkcayNEDTl8tByEXOVwWIS5+qXU/UDmZkfKdvoI9+8IDEpKj3lKB9WU0TLhPjEAwb2ZkgxYoYZuMgIt+yOETFQaQuUbSD1aXghYrTn4Fc6dI3DfDLhKaUjgEX8qEKD1eZFQecepPjhgNhVDQbmI6ZJuaCEnp1L8QUW0hsU7yOLtSEXMXCR65XE7IoxMbtJdzyjn9e+Z88YDd5xPHALG+P62Mli5ftNuQar2XPBL+Vzx4P+28gWuMQnSiegLpsYqDBNnRWoMdcnviz2Qr513Ed8gzWK908gCYWlPKtPzb7LBnKPbygd6vGLVmnDNTYqPbMjiOmv7ExLAANez7JZ8T42uNYF0M/PLNzmDDEaNbaa7POw8mG2T5XWSsGFiVqVdqbWS4xm/fIDBXeiGA7Gi2WSgwSQOQE4JxkclG/iF/Ve97GzoqGfA14vzBbvamoJdnGrhEueD7iPmm/S2UtMF0VDP1ZgMfeU2LXrZGHcmMNLhD1pDsgxyaXO/KKrl5gaRUN/VGilDWcAO6TdWc6QkAZJ9OHrCsxkL/5SvFtjRcy+CodC9sjCLkzYrySmJiUOgMZ4/0kJLKMUjRliOilnTILcnplfwD7uT4mHo5kxXRIe2uFYxbuH+EgZGKtuCQ+m3+SAd4F5sEK/jmTG5FGDGWI0+V+9Eh7aoU7x7l4vMZqsltqEh3boqXh3t5cYTTi9R0JOux/qSdqoQYYYzYlhJBCclvBxGPgWmpPdP3mJ2ajsTGPCx2GcpXz/62xVtl7R2JkJHybfYn22KvuZdBHR/ol3dgjYFj5V8T4myB4vMVoHAKcDRiS8HCoi10dJDGUTo60lfHHCy6HL7TRYk4sYbL1qNpWgzobGmJShyoXlJvJsf6ey3DSNd4a96ikxJmaKUo3h2+/KRQygrZ3SaOAuRhGotq49KXGEKckmZqHSbcYvZloMiZlOuuOR+OaLChGDOI02WxHV7EbFiBSUodRWD9lCWSclcmXQa4+toZMoYhOHXVHs/qJgq7a43sLsP+Qi5n0D1xk6d1YMiHlcxqp1kReXQgy2mecbdBpF066uYlImU/ruGzKYLe02Kju0tbXlevgYSidHaw8zwTe/giqTdOcSsKNvk74eAhIvRlKO6H6+U1r7DWwNie5FSfXuVUQKDng1k03Fw0WUZ8sl34whMd5fkE1IHzr00iohZhnZXKyA2XIB5ckYLXSuEdkaKEm702jmLKHgL6uzBO4uw904pxi0lakLmjeNt9CMyWCp4bpkuRjNqFXOwPmheWQXC8RdMwWj8aWcBJ5JNhXtSFTAEopW+fkmUV9WpOwoZSlRCjFrxaVrNRzoIpk5YQfO4KCan9VNSttlnfhpsQdLUWUZ4Ba7YYaDBtEIc99G4Sgfn21P5sh46wzbxXjPLelJEFOi9GPZ3GaPr1imlNEP1zKZ5UsH48S3G1RqP/x0+lsHnd7GsoxlVAUJGcOyQvpije9ZppXTn3JUWQaoPTzGkQHfKdGCubLAdV3JKSWRiWsonUzi4jbCreKN3lLOS36IIQlHDCK3Ny6tESMJY7nKuG14WKPFEXG5sYdwPmoTlH1dsV9igHdJn3xQCpA58psMEmRhU2ljGQ4DLtQ5XRa5jfJjqqVg0q1wmfZFfl7UEFMj//EwCh7rJDKBHKxfhDgvugoh3aSfgyrQR2ydnE8+CwtpiCEJsSwhh5dBRxQtoip9316uJQbAFsGblE4u7x1zQjaJA4PbLlQ1py2Ks2GLYKwY6NYYk7JDbN9IMigEblmZ9Spxc+NITquErSZaNWihyrKBrBFc99QnJqRgnXIv2WwsOiUGQJi8WexOtRK0XWzKbaRLyA+UmAxw3/CkCrmrLoG1FIqzOrsm0jUxQL2oNteRgqC8LqiuO8nuMrmKEZMBUn2mk7uYlGuPC8XhnrG2JWEgJoPxQlBtBOzPDlmXvEbpSuSBoRLEeGcQdjH7h5CgzJnUtyhH+mq1E5MBgosIvSPVtGcF1RyCpAiMotDoK2JLKoYwEOMFYm4IyePkL4KQrpM2kCG6T8hooXRQNhQIGzHZ3twQmVEDKF1+S5vAjYjvHs8apMXFGqTaiclGV7FFSFFFgkQ3cSDw9+wjH9j53Cuq6Vcx4jh/so0UEd8g8b8AAwDUzLkKXEhJOQAAAABJRU5ErkJggg==" alt="Red dot" style="width: 38px;border: 4px solid white;border-radius: 50%;padding: 6px 8px;"></button>
      </div>
      <div>
        <div style="margin-top: 4%;"><button type="button" id="up_button" class="btn_click" onClick="" ><img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0UmVmPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VSZWYjIiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDpBOUVCNDBDNUUxN0UxMUVDQTIyREFBNzY2MUFGRDQxNiIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDpBOUVCNDBDNkUxN0UxMUVDQTIyREFBNzY2MUFGRDQxNiI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOkE5RUI0MEMzRTE3RTExRUNBMjJEQUE3NjYxQUZENDE2IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOkE5RUI0MEM0RTE3RTExRUNBMjJEQUE3NjYxQUZENDE2Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8++QDtPAAACZhJREFUeNrsXWtsFFUUPmy3j10ehYaWUlMCtYbGaknLq0IpoqY2pQ0CivxAIsSgEYJGSNRgJJCgokDUUGMwsQI1Kom0CFSsQaQWqeUVULRopcjyKK1WirjbdrvUc5Y7uF129tW589jeL/lisLszs983995zz9y5Z0BPTw8YAInIDGQ6cgwyFZmCHIFMQA5BWpHRSCfSjryGbENeQV5C2pBNyEZkA7JVzz94gE6NIfEnIicgs5FZyCQFj9+CPIU8gTyKPMJME8b4QCZyBjIfmYccqeK5LyNrkTXIA8jT/d2YeGQRshBZgEzWwQ3SjKxG7kNWIdv7kzFpyEeQs1gL0SuoBe1CViLPRrIxZMg8xmwwDmgs2sF4NpKMoS5rAWMuGBd1yHLGdqMbU4JchJwNkYMKZBlytxGNobnGEsYkiDxQyL2F0WYUYyjKWooshsjHHmQpi+J0bcwy5HNslt5fQNmEd5Cb9WgMpU1WIlcgo6D/wYXciNwACqR7lDJmLPJFNsj3d1BQsB55RmtjcpCrkHOEJ7ewE7kOeVwrYyYhX0XOFF7chr3Itcj6cL5s6mNLEabIYybTJ0dNY8ay7kuYEticVUwv7sYksoFejCnBYQ7TK5G3MStF9BUyFjHduBmzjM1TBELHCqaf4sYUshl9lNA4LEQx/QqVNIYSkpT7Shf69gnpTMdUpYyhDHGx0FURFDM9+2xMSTAHEggJS5iuYRsTzyKKJKGlokhiusaHaww9Cp4tdOSC2UzfkI1J8/dFAUWwgOkckjG0kiVXaMcVuUznoI1Jk/uCgOKY56vVyBlDi/GyhWaqIJvpHdAYihRmCb1UxSzvCM2XMbSWOF9opSryme5+jSkUOmmCQn/G0KsQBUb7RfRwvLTJCR+ed8JfXT1GNaaA6e+G2euP9H5KspF+TTf6sOh4B3x8wen+96bBJqieYoWUuAFGMyaZ6X/aV4sx1NjicAHMrXfcMoXw8z83IO87OzT+e8OoY81tXRm9XpdnlF9wDZtKUZ0ddjd33/a3c/YbkI/mnGw3nDl5zIdextA7jyONcPUtnT3wQK0DDv7pkv1MM35mxiE7HGpzGcmYkcyHXsZMMMKV/4GtYXqtHY63Bxb8qrMHHv7eAVVXuo1kzgRvY3Q/02+4TqY44Mz14Lsou6sH5uA49OlFw5iT7WkMLa3J0vPVHrvqcreU847Qx40u/MoTxxzw/jmnEYwhHxIlY2hzA90+DPsWx5IHDzmgtVN+jrJ4VDSU5cSBWSZKxoYDz57sgNd+7dK7MeRDhjSP0e0iiy8w6pp/xAEdfhrKyvQYWJ8ZC+RJQvQAmH/U4Q6lfeGVXzqhDSehb91z8/M6RbrJI1TWHbbbnPBovX9T1t0dC29m/i9ySbIZqnKtMMQsL/um37vgqRMd7lakU4yRjEnV25W9e7YLnsQZfbeMeFGo+3vj4uDlu2Ju+9v04VGwf6oFEmPlzSk774THsSV26nOqkyoZk6Knq1rT0AnP/9gJcjd0DF719vEWeGZ0tOwxxg+NgoN5VhhlkX9Iu/NyNxTjJPV6t+6aTop01SP0cDUkz/JTnbDmjPwAbcWmUjnZAvPvMAc8XsYgE9RMs7j/K4f9rS54COc6Okt+jpCuOEHrK3Fil7LwWAdsbpI3ZRgO7NVTLFCYZA76uNRiqOVQC5JD/d83Q/GLHboxJ0F6o+wq+FnjxBsUQVEk5SvvJSEZx4sv77PCuPjwXumh3NqsH/yncUZbTW7j0weatDamXTKGbtNoLa5ATcHUuAGU6kAkYzRpw5SMLDrs8Jv3yhxsgq8UfL5C4/xiDJXLbfJZgKHYZe7OtcDUBO1ebJBuC9VzFcEkIycPuxlZKfnQi6Y3W3PiYHlajOxndJD8dErG2NU8KyUj89EUf8nIhxKj4GvsvhJilJ+f0xHfvjcWVmfEyn5GSn5+ckGT/JpdMuaaWmeUkpE2h3zvOWekGbsSKwwy802arB4b4zZI7iyU/FyIk1wNkp/XJGPa1DhbsMnIzyZaIFalsZe6tK36S362ST//Cu8zUTKy6LDdHYXJgZKRH2THudMtamJBajR8PskCFj9jPSU/V/7UqVaUdEUy5hLPs2wLkIwkH7yTkWpDZ8nPS5IxNl5noGTkogDJyFKZZKTaoOTnN3mBk5/z+Cc/bZIxXDaDViIZqTZy4gMnPyv4Jz+bpLM38giJX/9NmWSk2gg2+fmRjVu01iidmfa6b1H6x1Fr8DWQh5OMVBuBkp9PYytfOoZL90s+NEjG0I50p5Q+w2MpZijNius1oFMu6gD+4CkJ+t/HgcYaeuB2//De1zoPW/lmr9+lIMiHVs+2eoLHWZbgnUURF4GSkTXTrJA1xARGAUVpezFao6iNUICtfFuOhWdI7/bBsy85yutML2HENRBvurkp0UZc7O2e39A85w0cM1+4M9odtHCE2wfPHf5oQcYhMMgy2QgFVeWY6hmVSSFzrdBGU9RKUxfvRlkjtNEUt/T3NoaK2jQLfTRBM9PfpzH0NlO10EgTVINHpSdf8cU+oZEm6KW7L2OqxFijydhSFcgYKlizS2ilKnaBV6EgualSJa9MgIDPmX6l9/+UM4bqcO0QmqkCn3XPTAG+UCd044o6uQbgzxhysVxoxxXlIFMl0BTEFyuEflxQ4e/GD2QMRQpUqKZF6KgoWpiu7eEaQ6CSgluElopiCwQo1WgK4UB7hJ6KYE8wN3qwxtDyJiop2Ch07RMamY42pYwhUC6HSgq6hL5hwcX0CyoXGepDUqrzuFFoHBY2Qgh1MsN5er2BRRQCwaOM6QY8jaGlTlTncafQOyjsZHq18jaGQMU3qc7jXqG7X+xlOoVcrLQvC3Go+OZaYY5fU9ZCmEVKReVYft2XppVjJYhay70Hel3UWpYgqpPrsDq5J6ikIFWv60+F5hrZ5HGzUgfkYQyBtkOn6nX9oeAc5b5KQeHVRbyMIdAeaEsYI7HGGaXutzAq/qokT2MklLCgIJJqnVWwQX43rxOoYQyBdnZawGjk8lr0jL6csZ3nidQyRoJUYotopIpOtMRoB8isaIkEYzwNovJPVGlIz4UeaIUkLcarVMsQrY3x7OKKWBRH9VP0UCKFVt1XsyirineXpVdjPEFFbWawFkRVIdR8s43e5KplLYRehTittRh6MsYT9NohVYWYwMaiLIVDbgp1T7Gxg955PAKcNqGINGO8QemeDJZNGMPmSLQlMe1+SxutDkFa4eb2kbQrAu2/Rlt90a5StIHRJTbXaGKz9AYl0ibCmH6I/wQYAIByJEXmuf0BAAAAAElFTkSuQmCC" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;"></button></div>
        <div>
          <button type="button" id="left_button" class="btn_click" onClick="" ><img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0UmVmPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VSZWYjIiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDo2MjIzNkQzN0UxN0YxMUVDQjRCOEREQURGNkI2ODFFNSIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDo2MjIzNkQzOEUxN0YxMUVDQjRCOEREQURGNkI2ODFFNSI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOjYyMjM2RDM1RTE3RjExRUNCNEI4RERBREY2QjY4MUU1IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOjYyMjM2RDM2RTE3RjExRUNCNEI4RERBREY2QjY4MUU1Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8+EmAgSAAACPRJREFUeNrsXW1sVEUUvbv9roHGhn5AqLFYBfmKJQUqkib4AystVtDwA4nCHyKCmgiJAkoiQqIIGgioQdHE9IcQ04LQBhujCWm0YFNiCQhSqKTSlqI0VOjX9sN76ry6Xd9st93dvpm37yTnBym7nbmn82bmzH1zXf39/aQBUpjTmFnMTGYGcxIzjZnMHM9MZMYwPcx2ZhvzFvMGs5HZwKxn1jEvMm+q3GGXosIg+HOZOcxs5mxmagi/v4VZyzzLrGb+LERzhDHBDOYiZh5zIXPiGP7uJmYl8xTzB+b5SBcmibmEmc9czExX4A+kmVnBPMksZ96OJGGmMJ9mFokRoiowgo4xjzKv2lkYCLJCMJv0AeaiI4JX7SQMHlmrBHNJX1QxiwVv6y7MUuYa5jKyD0qZXzCP6ygM9hprBVPJfsCS+6Bggy7CYJW1nllI9scJ5gGxilNamA3MV8UuPVIAN2Evc7+KwsA22cTcyIyiyEMvcw9zN4XA7gmVMFOZr4tJPtKBRcF7zEtWCzOHuZW53NFkECXMncwaq4SZx9zGLHC0+B/KmNuZZ0bzYXeQI8URRY4CEZ85YynMVPH4ckQZXpytIl5hFyZFTPTOnBIYlot4pYRbmE3O6mvEWCPiFjZhNoh9ioORY6OIX8iFyRc7+ignxqNClIhffiiFgSEJ7yvLiW9QyBJxzAiVMHCItTckt1zoorcvdVvdjEIRT7+IDuCLlgbyRarj/bpuevfyv6K0dvfTh7PiyGVdc9aKjefx0Y6YJLGi0Po85dA1D71xvmvw3/uudtOamk7qsS4PJVXENWm0wuAoWOuTx5KmHnrxl07y1eDLBg89e6aDOvssa9oyEd8RCzPF3wd1wPd/9tLK6g7qlYyMC3/30Z0eS9O3Vok4j0gYZLJomzhxurWXnqrqoG7JiJic4KKKBQk0IdZlZTNzRZwDFmaK7AM64FxbHxWyKO2SoZIS56Ly3ES6P9GtQnNXmI0aWcuQjJetoyhX7vZRQVU7/dVtLsq4aBd9Mz+BZo53q9LkbBHvYYXBSqFIR1Gau/rpyZ866I8Oc1FiubelLMr8e5UzL4p8V2hmwiCXOE83UW57+umJH9up7q75pBLFU8nhuQn0+AQlHaU8EXe/wuTrJgrmEowUzC1mwPT+6SPxVJQerXI38v0Jg1chFuskClZdz5zppKrWXvmuf2Ycrb4vRvWuLBbxNxUG76ek6yIKFl0v1HTQty090v+z5aFYeu2BWB26ky7ibyqMNnMLpveXazvp8HW5KOsyY2jHw3E6PQDyzITB63ULdenB1gtd9MnvHunPn5scQ/tmxes2XS4UOgwRBu88TtSh9bsu/+cUm6EgLZoOZccPrMQ0w0ShwxBhcnRo+WfXPLT5Qpf0548lR/GyOH5gz6IpcnyFUX6nD6d4nYlTbGAW7+ZP5CZQooZDxVcHQxik1sxWubXDOcVZ97jpuwWJlBSjtSgkdEgxhMHlBsoehgXqFMOctAGgwzRDGGWTLDRzikOFLLfXUlk5aOgUhwqZRo8yVGuZxk5xKJBhCDNJpVZp7hSHApMMYdJUaZFNnOJgkWYIk6xCa2zkFAeLZEOY8Va3xGZOcbAYXM4kWtkKmzrFwWBw8W/pswHzxm935Jl308e5aa9+TnEwiDGE8Vg9YtLj5XsRJOZt+7UrkoTxGNFot3rEfJ4dT0vS5Cst2PxIDI8QtBvCtFndEmwYj8yNH7DtZUBiOBLEIwBthjC3lJjxeOcI236WxGLBIw8J4rD/bY5bRgRuqNIi2Paw72Hjy5bVsP9xDGBj3DB636hSq+AYw8aHnS/biOIY4HSrbcVpNIRpUK1lsPFh58vOWGDd4DhAZt1ojgZDmHoVWwc7H7Y+7H0z4DgAxwJX7tpOnHpDmDpVWwhbH/a+LLkCxwIwPXFMYCPUGd3FXfctqrYS9j5sflmOBY4HcEyA4wIbADpcNITBjXS1KrcWNj/sftmpPuYajBzZEbRGgA43vR8QZ1VvMez+XTPkRiaOC3Bs0K33lDOgg7cw1Tq0emNWLG1+UG7949hgdY08zUkDVPsKg1IdTTq0fOf0uIFjABm+ut5Dr5yTJwYqjCahwxBhsGSu1KUHSBhfOVkuzsf1noHEc81QaWxdfBehp3TpAVZoNnSkB+PvKwyK2jTr0gubOdLNIv6mwqDSUIVOf2I2cqQryKvSk1lvTpJmsIkjPSTuZj0p12muMaC5I31KxN2vMChYc0zHDYDGjvQx8ikUJMuAOKqDE2AGDR3psyLeFIgwqMN1RNets2aOtGndM/cwH6jSVRxNHOkq2QDwJwxULCaNMZwjjbvK3Na+hFZMkiqB7gA+WKqzOHCkkYhuJlrZo4nSuWgMUOrvD384YbBSQKGaFp3FQSI6EtINPJ8RQ1/PS6B4615EaxFxlZZsDLR+zDvMN0lzrK/tpFiXiz6w9mpfYAfzLX//IVBh8CrgR6T5pdh93FW39S82owrgSzRMZlKggxlfgpKCdToLo4AodSKOw6aLjeQpCy8HJQVtnQIZRvSK+AXkRY50+kOdxz1OjEeFPTSCOpmjWZfsFisKB4HjCxE3CqcwSHVCnccSJ94BoUTE62a4hQFQfBN1HsucuPtFmYjTiIuVBrPFQvHN7Y44fkXZTqMsUupUjg3f48vSyrEGnFrLQyd6JWotG3CqkytYndwbKCmI6nWRVGiuTmwe94fqC8MhDIDr0FG9rjACRIH3dYBCnF0ULmEAGJ9rBVNtKAis+4OCIX9VMpzCGFgqFgXLbCRKqZjkj4frF4yFMABqo6wSzNVYEJzRFwveDucvGithDBgltkCdKjohxegISTJa7CCMt0Ao/4RKQyoXekCGJJLxjo6VIFYL4/2IWyJWcaifokKJFGTdV4hVVnm4H1mqCuMNFLVZJEYQqkKMZQEIvMlVKUYIXoU4b3UwVBLGG7gHGlUhcsRcNDvES24sdWvF3IF3HvF6nVKXUKgqjC9g90wTbkKm2CPhSmLcfouLVnGnJ66PxLt/eEsJ96/hqi/cKoULjBrFXqNe7NIvhsI2cYSJQPwjwABd/hZSGqvCqQAAAABJRU5ErkJggg==" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;margin:15px 5px"></button>
          <button type="button" id="ok_button" class="btn_click" onClick="" ><img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0UmVmPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VSZWYjIiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDo4QTNCMTI4NEUxN0YxMUVDOTI2RkQ4RTNGOUM0NkU1NSIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDo4QTNCMTI4NUUxN0YxMUVDOTI2RkQ4RTNGOUM0NkU1NSI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOjhBM0IxMjgyRTE3RjExRUM5MjZGRDhFM0Y5QzQ2RTU1IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOjhBM0IxMjgzRTE3RjExRUM5MjZGRDhFM0Y5QzQ2RTU1Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8+BXoRMAAACSZJREFUeNrsXVtsVEUYnt5pi62iLYUISq3QgFbKRas0TXgQaoEgJJaQ8CAx4AMYoxCNQXwo+mACJkZ4sEjwoYkBEy5SKtYHIilagdhaJFwsbUJNb8il1bb0sq3/t85ptruzu+ecPefM2e58yffS7e7sft+ZmX/+OWf+uLGxMRYFyCLmE/OIc4iziDOJ04nTiBnENGIScZjYT+wl3iV2EduJbcRWYjPxGvG2m39wnEuNgfhLiUuIhcQCYraFn99NbCI2EC8RL3LTlDECLCAuJ5YQi4kzHGy7g1hHPEc8S7wS68ZkEsuIpcQVxBwXXCCdxFriGWINsSeWjMklvkpcy3uIW4EedJJ4gtgymY2BIeWchSx6gLnoKGfLZDIGQ9YmziIWvagnVnH2RLsxa4ibievY5MFx4mHiqWg0BmuNrZzZbPIBIXclZ1u0GIMoaxtxNZv8qCYe4FGcq43ZTnybr9JjBcgmfE7c70ZjkDbZSdxBTGCxBw9xH3EvsyDdY5Ux84jv80k+1oGg4FPiddnGLCLuIq5XnozjGPET4m+yjHme+BFxlfIiAKeJFcQLZt4cH2FPUaYExyquzyInjZnHhy9lSnhzdnG9bDcmi0/0ak7Rh/Vcryy7jdmpoi/D2Mx1s82Y7XydomAcO7h+lhtTylf0CUpjU0jg+pVaaQwSksh95Sl9I0Ie13GWVcYgQ7xa6WoJVnM9IzZmjZ4PUjCErVxX08Zk8ogiW2lpKbK5rplmjcFW8Dqloy1Yx/U1bExuqDcqWIJNXGdDxuBOliKlna0o4jrrNiY32BsULEe5qNcEMwY34xUqzRxBIdc7rDGIFNYqvRzFWv8ITWQM7iUuUVo5ihKue0hjSpVOUlAayhg8CrFCaSQFK7j+QmPwfEqO0kgKcrj+QmPU3CJ/rgkwBo/XFSttpKKY+zDBGDzzOENpIxUzuA8TjFmidHEFvD4k+q1ApaC7f5T91DHCLt/3sI//Ggl4fdv0RFaSlcAWE3Mz9O1sN93xsIV1/RP+tjc3ib377JSw7/3s8gO2s2VY+FpjcRoreNTW3fVCX2Nwa02BDEP2Xx0UmuGLA10jXgIbHklgHyxIsU2cQ9cGZZrCuA9Z2lCGww0c3Qz7uXOE5fzYF9YUfxy5939PgIBW49ubQ2zL9SGZpjDuQ75mjKM3Wfxwa5gV/zoQ0WdAQAw5Vpqy4Y9B2aZoyEv0CZUdQUuvh73SIBb0w8cT2bKsRLZydlLA/CMSDUNOZlIceyM/JeILxUWmeP3Qeswsp1rcclFsSt0LqaxiceoEU7z9Oi2evfZUMut8Od07v4h6DsyOZEgNdqFIMsXrh2bMTKeGsLP/jgpNeSknMfTASwZ99WIqWz41MO/69Z9Dpr4PIrdgQ6pEU7x+aL9yuhOtVbeLQ+FwpmhIp2HrvaeTA/6OAKJv2NhzPuhl5RdcaYrXD82YaXa3BOG0kNcXG59MMvQ5GOrmJscF/P33Ox5DppSdH2A3hsbcaIrXD82YDLtbutk7Kvz7cyZEKM8OfM/V+/qMQTCBeU5kypFnUtxgitcPzZg0u1vq6As0BvMFhiejeCI9cJ5pvD8a9n2tfWNs4y8DwnkO2H1jyPCQaBPStF+YZHdLvYIfPD/d3ANtGQIz/x4KLyiG0mCmAOhFX9qwcDWBJE2ZYRbl6LboSsfaqOmOR/bPGdaM6ZfRup6rXHcew8SQ+H3hFGH4/U7jA9nG9Gvfqtf22UwgnNmrXDQsPpYcZ9gURHh7FgRmDTDcHZI7pPVqxty1u6WHBMJBADOTrWiiX/hwvGFTAKyhsJayOqMQIe5qv6bL7paChcV1Hcayy8HWQxk6hzJfU8aHrvnJwv/d1Sit13RpxrTb3RLCYlGuS5QNCIWaW+I4pWx2+MASG2UrBf+HzTe8FrCuuefxZp0loF0zps2J1l4XrPJx9ev98VgcYq0hSuuYWQ/54s38FGFGAe2hXYfRphnjyGHQuFpFURBS7uHMwXiPxaFoxR5sKDLao/fMTRaubbDL6jBaNZWanWrx4FLxnjvMeat+wJuB9jcEEVLe2X7h4vDgvGTd9wGEA7YXRBcOkqTYHnAQzVo4grPuccaj7dvLEBETsGgPZHxvv0HfOgJDWKSbZP5A+CzaCth9ZZB9RwFMpEOmnhEbfmiXB06ka3LqcsCQhj2YiHoe9ZQvilIt/27Bwmf0VofSNfDhtm+/bXCyr0IA7EpiO9kIENkhNW91T5nQOwpSZKZrvD74GnPJ6RkOu5LYTv6nbKo35S4KWTUz8DoM+abE/v0SfK9g38WBdI3XB98T/nBDxnmmbpOVCVTlWOYblWkhc53SRirqtKWLf2x4TmkjFeP6+xuDojadSh8p6OT6C41BpaFapZEU1DKfSk+iXPkZpZEUTNBdZEyNmmukzC014YxBwZqTSitHcZL5FQoKtu13wulMQAyjgevN9BiDOlxHlWaOQFj3LD7MG+qVbraiPlgHCGUMXKxS2tmKKhakSmC8jjceV/rZguOhLvxwxiBSQKGabqWjpejmuvaYNQZAScFKpaWlqGRhSjXGG/igaqWnJajWc6HrNQa3N6GkYLPSNSI0cx3brDIGQC4HJQU9Sl9T8HD9dOUijT6ggjqP+5TGprCPGaiTaebJob08olDQj8NcN2anMbjVCXUejym9deEY1+u23cYAKL6JOo+nle4hcZrrZLhYaSTlFlF8s0KZE9KUCmaySKmqHGvf8CW1cqwGVWt54kTvilrLGlR1chdWJ/cFSgqiel0sFZpr5ovH/VZ9oB3GADgOHdXrYqHgHHJfB5jFdxfZZQyAM9C2ck7GGmdI3VdyWv6opJ3GaFjDg4LJVOvsOJ/kT9nVgBPGAKiNsokzmstrYY++irPHzoacMkaDVmILjKaKTrjF6CgLckfLZDDG1yCUf0KlITcXesAdkrgZ74RThsg2xneIK+NRHOqnuKFECu66r+VRVo3dQ5ZbjfEFitos5z0IVSGcfLINT3LV8R6CRyGuyBbDTcb4Ao8doirEEj4XFVgcciPUbeJzB555vMgcOoQi2o3xB9I9+TybMIevkXAkMU6/xUGrONMTx0fiiVac4IDz13DUF06VwgFG7Xyt0cpX6desSJsoY2IQ/wkwABV766fcDGemAAAAAElFTkSuQmCC" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;margin:15px 5px"></button>
          <button type="button" id="right_button" class="btn_click" onClick="" ><img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0UmVmPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VSZWYjIiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDozRjdCMjQ1NEUxN0YxMUVDODY4NDk4M0Y0QUQwM0EyRSIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDozRjdCMjQ1NUUxN0YxMUVDODY4NDk4M0Y0QUQwM0EyRSI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOjNGN0IyNDUyRTE3RjExRUM4Njg0OTgzRjRBRDAzQTJFIiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOjNGN0IyNDUzRTE3RjExRUM4Njg0OTgzRjRBRDAzQTJFIi8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8+IYnZJwAACOZJREFUeNrsnV1sVEUUx8/u9nPVNlb6RSharIIiaEmBQrAJPjSVthZIJCE2KsbUiERjIMHYxIcajSStiQoaqshLE0wxbRFbsPiRkAYKFNASCIZKhWJLW1JtE3a33Zb1nHUu2a737t7d7vbOzN5/8n9h2Xbu/Dp3zpw7d47F4/GAAEpHL0LnoXPROei56Ex0GjoFbUfHo91oB3oMPYIeRPej+9C96B70ZfQwzxds4RQMdf5ydAE6H70UnRHBnz+E7kafR3ehzzBoJhgVLUavRReh16CzZ/F3D6A70MfRv6AvxjqYVPQ6dAm6GJ3FwR/ITXQ7+ii6DT0aS2AWoNejK9gI4VU0gg6hW9BXZQZDQDYx54M4ormokfmqTGDollXJXAjiqhPdwDwqOphy9Bb0BpBHzej96MMigqG1RhVzBsgnCrnrmftEAUNR1hvoMpBf36P3sCiOazDb0G+xVXqsiLIJn6B38wiG0iY70NvRNog9TaHr0LUQgXRPpMAsRO9kk3ysi4KCXejfjQazDF2N3mgyuasm9Afoc0aBWYF+D11qsvifWtE16NPhfNk6w5FiQtFWKeufZbMJZiG7fZlQgsOpZv0VdTDpbKI35xR92sj6Kz3aYHaY0VfI2sL6LWpgtrF1iqnQtZ31X8TBlLAVvc3s47BkY/1XEkkwlJCk3Fee2b8zUh7rx5xIgaEMsWEJyZ+Gp6DkpBMcUx4Z4JSx/pwxmHI9Pyhaah6YhLJOB7QPTcLzZ1wwcUeKkVPF+jVsMKksojDkecr+627YdMYJ4wzGkcFJ2HLeBRIMnAzWr6nhgqFHwYY8efz4jwl4VQXCgRtuePOCS4ZRs4H1b8hgFgT6YjRFLM7+cwe0BsYXvW5499K4DHAqWT+HBIZ2shiyccJCt7H8JHg2M07z/3x0ZQJqeyZEB1PI+lk3mAVaX5gtJWDLDi5PgtVp2sumnRfH4evrbtHhbFIbNVpgaDOe4fu+7DYLtBYmw5IUq+Yt77VfXd7ITWDls/4OCoYihQpeWp0ab4Fjq+2Qd486HAoONnc54edbUyLDqfCP0NSulvYSc7VtNSPRAj+sToZ5yRbVz2ltU9HphFN/CwuniPV7QDAlPLY8127F25od0hPV4dzGoVOOcC6MCbsCLQkEhl6FKOa15TTXfLcyGe6NU4dza8IDpZ0OuHpbSDjFrP9VwdD7KVk8t37l/TZoQTgJGmHLDafHm1cbHBcuPZDF+l8VTJEIV/DMHBscKEgGm/rAgR4cMcUnHDDqFg5OkRoYer1ujTD5jOw42PtUEmiw8c41pZ3CZaTXMA7TwNA7j9kiXcUr8+Nh1+JEzc9PjEyJlpHOZhymgSkQccbckZcA7zySoPm5gBnpAn8w+SCoPnw8EV7Pjdf8XLCMdL4vGNpas1TkpfOnS5Jg8zxtOAJlpIlDugKGDjcQ+uUiitAkyUgTh0UKGCk2WUiUkc6z+oTKUkiSjHSu0vockEgSZKRzlJbPBckkeEZ6rgImEySUwBnpTAVMGkgqQTPSaQqYFJBYAmak74YudpBclJH+RpyMtF0BEw8xoPXZcVD1kPalXnN4YJKPQROvgHHHAhjanL7vmjtgJMfJzcytgHHIDoXC4opTTs1HABRWH8Pwek6ChYfmOhQwYzJDCfbQjMLpI6vs8KDdykuTx5SWjMgKhSZ1CodHJtShpGAYTeH04vusPDV7RGnNoIxQBlweWIdhMIXDaqLwuQmhUDjNmQYVMP2yQaGwt+Skwzti1ERhc+PyZG8YzaH6FTB9MkGhuYQWjFqpFprev8pPguey4ni9hD4FTK8sUCjq2njaFTA5WftEIryUw/XSrVcB0yMDFAq6Xjzn9L6vqaXqRxPg7YcTuI9ZFDB01v2QyFBoet/W7YLGv7Sh0IaN9x9L5P1SiMNlBQydSNctMpjqS+Ow90/tVf0L8+LhsyVJIlwKcRj2Dd7Piwpl15UJ70YLLZXhJL8PJ3urRYjL8XLwBdMlIpQvrwXelvT0A5RVTtJM+XOoLn8wVKpjQCQo3/ZPwtbfXJqJxydT/3tIZrdZRLmkAcZhGhgKmTtEuYIfh6eg8qxTc+srbcRoX2X3bswQSB3K0sV/gB8XofW0RlmvI1Os9ayfY93tf38wVNTmJs8tFzBTrFc3Wf+rgqFKQ+3crrrEzBTrVTv4VHpSu4KjPLZa4EyxXk3rdzUwbbzNNYJnivXOLW3BwFDBmkO8tFiCTLEeHQK/QkFaN+MWHjIBkmSK9az0W/z/UQsM1eFqNLK1EmWKg0m17pk1yBc6jWipRJniYOrUGgCBwBDFBiNaS/NGeoBtRAJlioOpATSqBFp1fLHZiBbX4Giow/nDH49gmeJAag70hx8MDEUKVKjGkIdoNH8QBCUHKWCmWEtDrF9HwwVDopKC9UZdwcvz4+EgrlFW4MJRsExxINVDkFKNegv70KuAn4OBh2J72NwjgagK4FYIsjNJ702BfgiVFDRs04YkUHpYPwbdLhbK3ZpyOVRScApMhbU0Y/2nKxcZ6jRKdR7rzD4OS3UQQp3McOKbWhZRmNKv/azfIJpgaKsT1XlsMvtbl5pYfw1HGwyJim9SncdWs98DqpX1U8jFSmeyVKPimzUmnIBQaiDMIqVm5djo3b4MrRyryKy1PH2i56LWsiKzOjmH1cl9RSUFqXpdLBWa62GLx92R+oHRAEOi49Cpel1ZDECh3NceiPDuomiBIVHis4o5Q0IglLqvZ474q5LRBKOonAUFGySC0swm+cPR+gWzAYZEtVEqmQsFBkLP6BuYR6P5i2YLjCKlxBZZpHOeaYtRI2jsaJEBjC8gKv9ElYZ4LvRAOyRpM17LbAExGozvLW4di+KofgoPJVJo1307i7Laon3L4hWMr6iozVo2gqgqxGwWgKA3uTrYCKFXIS4a3Rk8gfEVnQNNVSEK2Fy0NMIhN4W63WzuoHce6fU6rg6h4BWMvyjds4hlE3LZGomOJKbTb+mgVTrTk46PpE3M9E45nb9GR33RqVJ0gFE/W2v0slX65UikTUwwMah/BRgAIYMWUTQwSWIAAAAASUVORK5CYII=" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;margin:15px 5px"></button>
        </div>
        <div style="margin-bottom: 4%;"><button type="button" id="down_button" class="btn_click" onClick="" ><img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0UmVmPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VSZWYjIiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDpGNDkzRUIwNUUxN0UxMUVDOUNDNzg5Q0FCRTA2RjVGNyIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDpGNDkzRUIwNkUxN0UxMUVDOUNDNzg5Q0FCRTA2RjVGNyI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOkY0OTNFQjAzRTE3RTExRUM5Q0M3ODlDQUJFMDZGNUY3IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOkY0OTNFQjA0RTE3RTExRUM5Q0M3ODlDQUJFMDZGNUY3Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8+dzopnwAACeFJREFUeNrsXQtsVEUUvbvbz+6CVCstLdposYTGT7W1YsVSRQ3UCiKIGBUxGINGUWLEaKLRSKKRKP4CfpoYIoIaAhSkVEQjWotW+cX6A60UUy0UkFDU3e1uP967zDPbsrPdfX3z3rztnOQktHR35t3zZu6d+97MdfT29oINkIUsRBYg85F5yNHIUchM5AikF5mKDCF9yBPIY8h2ZBuyFdmCbEbuRR6R+YIdkgpDxr8MWYosRhYhsw38/sPIJuQe5E7kDiaaEiYKLkBOQlYgy5G5JrZ9ENmArEduQ/441IXJQFYhK5GTkTkS3CCHkFuRW5B1yI6hJMwY5E3I6WyEyAoaQRuRG5D7k1kYEmQ2YzHYB+SL1jDuTyZhaMqaw1gG9kUjchVjh92FmYach5wByYMa5ArkJjsKQ2uN+YzZkHygkLuasdUuwlCU9QByKiQ/apHLWRQntTALkAvZKn2ogLIJryKXySgMpU0WIR9BumDooRu5FPkiGJDuMUqYccjHmJMf6qCgYAlyn9XClCCfQM5UmvyP9chnkbutEmY88inkDUqLU7AZuRj5rZ4POwc5UpQofNzA7FNipjDj2PSlRBlYnCeYvYQLk8UcvfIp8WEms1eWaGEWqegrYcxjdhMmzAK2TlFIHI8w+xkuTCVb0buUjXXBxexXaaQwlJCk3FeBsu+gUMDsmGeUMJQhnqrsagimMnsOWphp8XyRQkKYz+yqW5gMFlFkK1saimxm1wy9wtCj4BnKjkIwg9k3YWHGxPqggiGYw+yckDD0JkuZsp1QlDE7xy3MGN4HFAzH7GijhicMvYxXrGxmCoqZvQcUhiKF6cpepmJ6/wgtmjD0LnGFspWpqGB2jylMpbKTJaiMJQxthZisbGQJJjP7RxWG9qfkKBtZghxm/6jCKN9iva85RRjaXleubGMpypkOfYShPY/Ctte92xqCv4K9trUY9Xx5SwiCPUKbyWU69BGmVFRrb+AF3bU7AFc1+ODPgP3ECaEYc3cF4MGmANyxyw/dYi+htL8wQlb67/8Rgoe+D4T//dPfPTDxSx80/9tjG1H83QCzdvhh9R+h8M/r2rrgvu8CIFCb4khh6NWaIqNb+Ki9C+btCfS5ww74eqACxfmuQ35xTnT1QlWjDzYd6urz+7d/D8HjP3aKapZ0yNKEocMNDH0Y9ss/PXDLjkDUOflQZy9M2u6D7ce6pRXlMPbxmgY/fHE0eh9faA5C9YGQiKZJh0JNGMNfshg73An3nJPK/f/joV6Y8pUf6tq7pBPldxzV5A93d/BvnMvPcMGs0SmiulDgjAiVDYUD+cpF6fB0YTr3b3w4x8381h/2Q7JgL470ChRl3z/8qfa6LBd8MsEDmWkOUd3I14TJE9XC0+PS4LWidOBdAk11czFie/OA9eLsOt4dHimtfr5rvxlHSW2ZF4anOER2JU8TZrTIVhbkp8HKS92Qynn6Q8HB/RjpPPdL0DJRPkdfcu12Pxzp5ItCU/MHpR5IcwrvzmitiVGiW7rj7FRYd5kHPDHe43zy505Y9EMnmL3S+RCjrqqvfeEojIdHC9LgrUvc4HKY0qVRmjCZZrQ2NScF6nAaGBFjGnjptyDc0y/EFomVrSGYhX4u0MP3lc+enw5LLuBPxwKQqe0oOw4x3nEyGhTtVH3tD4ekPMzITYH3cNpIFzhtvLY/CA9/zx+hNDqWFbnh3nNTzZ5ZOzRhaHI3tXWKeipRHApNebgWo5+a8R4hjvaZvZ3wzD6+TyM/srLEA7PPSgELENKEsSSBRdHPlK984RCVh/G4Xthc5oEzDQpN6UIXNnXCsha+KMNwqKwd74Yp2ZaIcnIKtWrEaDga7IXrceRQqMrD+ac54eMJXjjLPThxKBl5N/qv1THWTWekOmAT3ggTMi3dbRKyxMdEy0nd9I0/HLLycK6XxPHA2GH6nA4lI2/d6YfaQ/xMQ066A7bgDVA0wgkWo0PrwQkre0FRWt0VXrgxhz91UPLzKp3JTy0ZGUuUfBT+y4lSiBLustaLY1b3xI09WYuOfm4ef0bVk/wcKBlJuBDFaEBRzhsmhShhPbSetMvQGwq+VpS4YeGYNO7fJJL8jCcZWYbBxedXeiHX7QCJ0K4J0yZLj8g8LxuQ/Iw3GblVbDJSL9o0YVpl61k8yc87OclPivDoYZwEyUjdKwlNmBYZezdQ8rMnSvJTS0YeDUqRjNSLFi0Mapa1h5T8zMC7mkJdP8dVUPLzGAoxcaQLbtvBz3sRKBn5vLl5Lz1o1tYx9Mz/B5B4r2X9X91wY6M/ZgbYESOFoSUjHx+bBpKDztq8UBvMdCJdk8y9rTjTBZ+VeyA73REz3RINlIx8/WK3HUQBpsORyFl2j+w9LslwwRflXjjHG79zID+y+lKPFRlivQjrEHmFO+3Q63HDnVCP4hQOH1gcSkZuvNyyDLFe7OwvDJXqOGiHnud5HFCPK/XS0/mJRkpG0hrFygyxDhxkOvQRhkLmBrtcwUhcFH56pQeuHnmqOJSM3Iaj6opM251H1KAtXfrPB/V2uopoyU/JkpEJB5//R5H9DiulHU2fgs02L1EEveTXYDgRejuueyTLe8ULqltzHbCiQtFOkX0HORcUzMZK5F3aD9HG+xZlI0vQx+7RhKmzm69JAtQzu8cUhgrWbFS2MhUboV+hIF7ossEOmYAkwR5mb4hHGKrDtUbZzBRErXvmHOADjcpuQtHIGwCxhCEVVynbCcUq4FQJdMbxwRplPyGoiXXjDyQMRQpUqOawsqOhOMzs2qFXGAKVFKxWtjQU1TBAqUZnAl9Uq+xpCGrjudHjFYZeb6KSgs3KroNCM7Njq1HCECiXQyUFu5V9daGb2S+uXGSiDy2ozuNSZWNdWAoJ1MnU8zTpRRZRKMSPFcxuIFIYetWJ6jyuV/aOC+uZvY6IFoZAxTepzuNmZfeY2MzslHCx0sE8GKfim4uVODFFWQw6i5SqyrHipi9LK8dqULWW+zp6KWota1DVySWsTh4JKilI1euGUqG5ZrZ4XGbUF4oQhkDHoVP1uqFQcI5yX8vB4LeLRAlDoDPQ5jMmY40zSt1XMxq+VVKkMBqmsaAgmWqd1TAnv0lUA2YIQ6BTN+Yw2rm8Fj2jX8XYIbIhs4TRoJXYItqpohO9YrQGOG+0JIMwkQJR+SeqNCRzoQd6Q5JexttgliBWCxM5xVWxKI7qp8iwy4Deut/Koqw60VOWrMJEgraATGIjiKpC5JrYNu3kamAjZBuwrRBWQiZhIkHnQFNViFLmi4oMDrkp1G1ivoP2PNL2OqkOoZBVmP6gdE8hyybkszUSHUlMp9/SQasjkF44eRgenWHig5NHfdGpUnSAURtba7SwVfpeI9ImSpghiP8EGABFlDJviKYNIAAAAABJRU5ErkJggg==" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;"></button></div>
      </div>
      <div>
        <div class="main_bottom_div" style="max-width: 320px;margin: 0 auto;">
          <div class="left_bottom_div" style="float: left;width: 50%;">
            <button type="button" id="plus_button" class="btn_click" onClick="" >
              <img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcE1NPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvbW0vIiB4bWxuczpzdFJlZj0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wL3NUeXBlL1Jlc291cmNlUmVmIyIgeG1sbnM6eG1wPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvIiB4bXBNTTpEb2N1bWVudElEPSJ4bXAuZGlkOjU5ODA1QjVDRTFBQjExRUM5NjQxRjI0MzRBMDdDODk1IiB4bXBNTTpJbnN0YW5jZUlEPSJ4bXAuaWlkOjU5ODA1QjVCRTFBQjExRUM5NjQxRjI0MzRBMDdDODk1IiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOjhBM0IxMjg0RTE3RjExRUM5MjZGRDhFM0Y5QzQ2RTU1IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOjhBM0IxMjg1RTE3RjExRUM5MjZGRDhFM0Y5QzQ2RTU1Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8+2SzXDAAABhtJREFUeNrsnU9IHFccx1/WeDFFwaJRwYMiRChYDLZ4EEECIolizCHQ4iUXLw30EKGHQA9CD4VYCCQXL7lICx78Q1SKEALBgyTSpJaAhUUPC/4FQWmlINb+vunvybiZ3Z2dnZn3Zvf3ge9F3NX9fnd23rx9876Xzs7OVAyoIbWSWkhNpEZSA+kqqZpUSaoglZNOSMekI9IBaZe0RUqRNklJ0jpp3+YXfMnSYGD+F6QOUjupjVQb4PPvkdZIb0mrpDccmgTjwmekHlI3qYtUH+Hf3iYtk16RXpLel3owVaSbpD5SL6nOgjfIDmmJ9CtpkXRYSsE0k26TBvkIsRUcQXOkWdJGMQeDQO6y2lV8wLloirVRTMHgI2uY1aniywppknUY92AGSPdIQ6p4mCE9Iz2PYzC41hhh1ariA0PuCVYqLsFglPUNqV8VP/OkpzyKszqY+6Rv+Sq9VMBswmPSExuDwbTJKOkBqUyVHqekcdIjFcB0T1DBXCN9xyf5UgeDgh9Jf5oO5jrpIemOZHLONOkH0m+mgvmS9D3plmTxEQukMdJrPw9OFHikSCiZucX+XI8ymGv88SWh5A7nIfsVejA1fKKXc4o37rBfNWEHMyqjr7y5x76FFsx9vk4R8ucB+xd4MH18RV8mHvuijP3rCzIYTEhi7qtF/C2IFvaxMahgMEPcL74GQj/7WXAwA16eSMiLEfbVdzBVPKKoFS8DpZZ9rfIbDL4KHhIfQ2GI/c07mOZsDxQCYZh9zisYrGTpFO9CpZN99hxMc6YHCIFz1+2oyRQMFuO1i2eR0M5+5wwGI4VB8StSBtNHaG7BYC1xt3gVKd3s+zmXXX6pLy6v5qc//lGjGydZf6fnk4R6ceNKHF4OfP8l0xGDWyF65Q1shF723zUY3J9SJx4ZoY79dw1Gzi3mzzUfBYPb67rEG6N0cQ4XgsE9j/XijVHqOYcLwXSIL1bQkR6MXOnbMxNwHgyW1rSJJ1aAHGp0MNjcQL4MswPk0KqDkUUWdtGScAyVBXto0sE0ihdW0aiDaRAvrKJB3x/zjvS5qf/ixou/1cu//rXOnXddFartUyMLT3/XR0y1vEmtoloHUyleWEWlDqZCvLCKCh1MuXhhFeU6mBPxwipOdDDH4oVVHOtgjsQLqzjSwRyIF1ZxoJcv7Zr8L/wuLyqy5UtOdvURsyVvUqvY0sGkxAurSOlgNsULq9jUwSTFC6tI6mCw1/2e+GEFyGFdB4Md6dbEEytADvvO5UtvxRMr+JCDM5hV8cQKVtODQVXHtvhilG3O4UIwGDIvizdGWdaXLum3YbwSb4xy7n96MCi12RF/jLDD/rsGg6ahJfHICEvK0fTktr3vV6SfxafI+VpluTkWLMq5xsi5ZdH5A7dgUFgzJ15FypxKKwrKtGXJrMwERHqlP5v+w0zBoIdrSjyLBNfes0SOB6yIb6GykukAyBYMUpwU70JlUmVoCUx4eOCM+BcKM9ne+LmCwUgBRTXyJVqw7LGvh36DAagUnBAvA2VC5ahqTOTxRPPiZyDMe3mjew0Gy5tQKSiLNgojyT6mggoGoOcRlYKn4q8vTtk/T32Z+daUoOdxXDz2xbjKoyfTT7HPIx5RCN55xr6pMIPBUif0PE6L356YZr/2ww4GoHwTPY8L4ntWFtinvMtKC6lbRPnmmISTNZQx5bOkVJpjw/v4Mtocq5Gu5Ysneiu6ljXSTm5hO7kTVAqiva6U9kBL8sXjk6CeMIxgALZDR3tdKRTOYe7rqdcretPBAOyBNsIqxm0dMXU/wQr8Vskwg9EM8KCgmLrOZvgk/zysPxBFMADdKMOsONdr4Tv6SdZhmH8oqmA0umILitM+z1hiNKUyrGgphmCcAaH+CU1DNhc9YIUkFuPNRhWI6WCcH3E3eRSH/hQbKlKw6n6JR1mLYX9k2RqME5Ta9PARhFaIKAsgcCfXMh8huBXivWkzbArGCfaBRitEB5+L2gIecmOou8bnDtzziNvrrNqEwtZg0sF0TyvPJjTxNRK2JL6q/t9oFXt6YvtI7FSIXX+w/xq2+sKuUtjAaIuvNTb5Kn09iGkTCaYE+U+AAQCV+ndEITBMZgAAAABJRU5ErkJggg==" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;margin:15px 5px">
            </button>
            <button type="button" id="minus_button" class="btn_click" onClick="" >
              <img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcE1NPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvbW0vIiB4bWxuczpzdFJlZj0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wL3NUeXBlL1Jlc291cmNlUmVmIyIgeG1sbnM6eG1wPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvIiB4bXBNTTpEb2N1bWVudElEPSJ4bXAuZGlkOjc2NjExMEVDRTFBQjExRUM5N0E4RDlGRUI2MzNEQkE5IiB4bXBNTTpJbnN0YW5jZUlEPSJ4bXAuaWlkOjc2NjExMEVCRTFBQjExRUM5N0E4RDlGRUI2MzNEQkE5IiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOjhBM0IxMjg0RTE3RjExRUM5MjZGRDhFM0Y5QzQ2RTU1IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOjhBM0IxMjg1RTE3RjExRUM5MjZGRDhFM0Y5QzQ2RTU1Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8+x89/ygAABe9JREFUeNrsnT1IXFkcxV90bVxQEMYvsFCECAuCwV1kESEQZEgU1xSpbNLYbGCLBLYIbCFssRCLQNLYpLGy8IOohCEQCBayKxsQAi4MWgz4CYJCbMR1/2f5X5mZzPe89+6dmXPgQAjMTHJ+8967785999y6vr72KkARcZ+4V9wt7hJ3itvELeImcaO4QXwpvhCfi0/FR+J9cUK8J46Ld8QnLv+HbzkKBuF/Lx4UD4j7xa0+vv+xeFv8Sbwl/kuhEUwGfSe+Kx4RD4s7QvzsA/GG+KP4g/hzrYNpFt8XR8Wj4nYHviCH4pj4nXhdfFZLYHrEP4kn9AhxVTiCVsTL4t1qBgMgj9QDXuUI16IF9W41gcEpa0o95FWuNsXz6rNKBzMufiye9KpHS+I34reVCAb3GtPqVq/6hCH3nDpRKWAwyvpZPOZVv1bFr3UU5zSYJ+Jf9C69VoTZhJfiVy6CwbTJM/FTcb1Xe7oSz4pfeD5M9/gF5rb4V73I17owKPhD/I9tMHfEz8UPyeRGi+LfxX/bAvOD+DfxA7L4SmviGfGfpby4rswjhVCy64HmcydMMLf19EUo+eE817wCBxPRCz2vKYXpoeYVCRrMM46+itZjzS0wME/0PoUqXk81P9/BRPWOvp4Zl6R6zS/qJxhMSGLuq5f5lqVezbHLLzCYIR5jrr5oTPMsG8x4IW9EFaVpzbVkMM06omhllr6qVXNtLhUMfgqeZI6BaFLzLRpMT64XUr5oSnMuCgxWsgwxu0A1pDkXDKYn2wso3/Uo01GTDQwW4w0ws1A0oHnnBYORwgTzClUT6SO0TGCwlniEWYWqEc09J5goc7KiaC4weBRilBlZ0ajmnxEMnk9pZ0ZW1K75ZwTDa4v9a81XYPB43TCzsaph5ZACBs88djAbq+pQDilgBpmLExpMB8M7fXdmAm7AYGlNPzNxQuAQMWCwuQF/DHND4NBnwHCRhVvqrUsaKlPuqNuA6WIWTqnLgOlkFk6p8xv9Q5vVE+r7L97ul3+dSyf2Y6N3L2Jl4WmbOWJa+CV1Si0GTBOzcEpNBkwjs3BKjQZMA7NwSg0GzCWzcEqXBswFs3BKFwbMObNwSucGzCmzcEqn5gbzyOa/In7vW6JI1ZE5YvaZhVPaN2ASzMIpJQyYPWbhlPYMmDizcEpxAwZ73R8zDycEDjsGDHak22YmTggcTpKXL31iJk7ofw7JYLaYiRPaSgeDqo4D5mJVB8ohBQyGzBvMxqo2zK1L+mMYH5mNVd3knw4GpTaHzMeKDjX/jGDQNBRjRlYU85KanjI9HPuOGVlRSu6ZwKzzWmPl2rKeDwwKa1aYVaha8dKKgrJtWbLMmYBQ7/SX0/8yGxj0cC0ws1CUsfesLs8LNplboNrMdgDkAgOK88wuUM17WVoC6wp44RLzC0RLub74+cBgpICiGv6I5q+ONdezUsFAqBScY5a+as7LU9VYV8QbrTJPX7RayBe9UDBY3oRKQS7aKE9xzTHhFxgIczmoFLxiviXpSvMraC6y2JoS9DzOMuOSNOsV0ZNZSrHPCx1RUIXrjebmBQkGS53Q87jIvAvSouZ1EjQYCOWb6HlcY+45taY5FV1WWk7dIso3ZwgnJ5QZr8SSUjbHBnf6stoca8Su5dQLvRNdy0ZsJ3ewnTxZqBREe10t7YEW15vHV369YRBgIGyHjva6Wiicw9zXa8/n1UVBgYGwB9q0uhq3dcTU/Zza90clgwRjNK6DgmrqOlvSi/zboD4gDDAQulGm1JVcr4Xf6OfVZ0F+UFhgjEzFFlxJ+zxjidGCl2VFSzWASQaE+ic0Dblc9IAVkliMtxwWENtgkk9x93UUh/4UFypSsOo+pqOs9aBPWa6CSRZKbe7qEYRWiDALIPAk14YeIXgU4rPtMFwCkyzsA41WiEG9FvX7POTGUHdbrx145hGP1zm1CYWrYNKF6Z4+nU3o1nskbEmM3W+x0Sr29MT2kdipEJviYf81bPWFXaWwgdG+3mvs6V36jh/TJgRTg/pPgAEA2OFik12zyl0AAAAASUVORK5CYII=" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;margin:15px 5px">
            </button>
          </div>
          <div class="left_bottom_div" style="float: left;width: 50%;">
            <button type="button" id="next_button" class="btn_click" onClick="" >
              <img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0UmVmPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VSZWYjIiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDpBOUVCNDBDNUUxN0UxMUVDQTIyREFBNzY2MUFGRDQxNiIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDpBOUVCNDBDNkUxN0UxMUVDQTIyREFBNzY2MUFGRDQxNiI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOkE5RUI0MEMzRTE3RTExRUNBMjJEQUE3NjYxQUZENDE2IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOkE5RUI0MEM0RTE3RTExRUNBMjJEQUE3NjYxQUZENDE2Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8++QDtPAAACZhJREFUeNrsXWtsFFUUPmy3j10ehYaWUlMCtYbGaknLq0IpoqY2pQ0CivxAIsSgEYJGSNRgJJCgokDUUGMwsQI1Kom0CFSsQaQWqeUVULRopcjyKK1WirjbdrvUc5Y7uF129tW589jeL/lisLszs983995zz9y5Z0BPTw8YAInIDGQ6cgwyFZmCHIFMQA5BWpHRSCfSjryGbENeQV5C2pBNyEZkA7JVzz94gE6NIfEnIicgs5FZyCQFj9+CPIU8gTyKPMJME8b4QCZyBjIfmYccqeK5LyNrkTXIA8jT/d2YeGQRshBZgEzWwQ3SjKxG7kNWIdv7kzFpyEeQs1gL0SuoBe1CViLPRrIxZMg8xmwwDmgs2sF4NpKMoS5rAWMuGBd1yHLGdqMbU4JchJwNkYMKZBlytxGNobnGEsYkiDxQyL2F0WYUYyjKWooshsjHHmQpi+J0bcwy5HNslt5fQNmEd5Cb9WgMpU1WIlcgo6D/wYXciNwACqR7lDJmLPJFNsj3d1BQsB55RmtjcpCrkHOEJ7ewE7kOeVwrYyYhX0XOFF7chr3Itcj6cL5s6mNLEabIYybTJ0dNY8ay7kuYEticVUwv7sYksoFejCnBYQ7TK5G3MStF9BUyFjHduBmzjM1TBELHCqaf4sYUshl9lNA4LEQx/QqVNIYSkpT7Shf69gnpTMdUpYyhDHGx0FURFDM9+2xMSTAHEggJS5iuYRsTzyKKJKGlokhiusaHaww9Cp4tdOSC2UzfkI1J8/dFAUWwgOkckjG0kiVXaMcVuUznoI1Jk/uCgOKY56vVyBlDi/GyhWaqIJvpHdAYihRmCb1UxSzvCM2XMbSWOF9opSryme5+jSkUOmmCQn/G0KsQBUb7RfRwvLTJCR+ed8JfXT1GNaaA6e+G2euP9H5KspF+TTf6sOh4B3x8wen+96bBJqieYoWUuAFGMyaZ6X/aV4sx1NjicAHMrXfcMoXw8z83IO87OzT+e8OoY81tXRm9XpdnlF9wDZtKUZ0ddjd33/a3c/YbkI/mnGw3nDl5zIdextA7jyONcPUtnT3wQK0DDv7pkv1MM35mxiE7HGpzGcmYkcyHXsZMMMKV/4GtYXqtHY63Bxb8qrMHHv7eAVVXuo1kzgRvY3Q/02+4TqY44Mz14Lsou6sH5uA49OlFw5iT7WkMLa3J0vPVHrvqcreU847Qx40u/MoTxxzw/jmnEYwhHxIlY2hzA90+DPsWx5IHDzmgtVN+jrJ4VDSU5cSBWSZKxoYDz57sgNd+7dK7MeRDhjSP0e0iiy8w6pp/xAEdfhrKyvQYWJ8ZC+RJQvQAmH/U4Q6lfeGVXzqhDSehb91z8/M6RbrJI1TWHbbbnPBovX9T1t0dC29m/i9ySbIZqnKtMMQsL/um37vgqRMd7lakU4yRjEnV25W9e7YLnsQZfbeMeFGo+3vj4uDlu2Ju+9v04VGwf6oFEmPlzSk774THsSV26nOqkyoZk6Knq1rT0AnP/9gJcjd0DF719vEWeGZ0tOwxxg+NgoN5VhhlkX9Iu/NyNxTjJPV6t+6aTop01SP0cDUkz/JTnbDmjPwAbcWmUjnZAvPvMAc8XsYgE9RMs7j/K4f9rS54COc6Okt+jpCuOEHrK3Fil7LwWAdsbpI3ZRgO7NVTLFCYZA76uNRiqOVQC5JD/d83Q/GLHboxJ0F6o+wq+FnjxBsUQVEk5SvvJSEZx4sv77PCuPjwXumh3NqsH/yncUZbTW7j0weatDamXTKGbtNoLa5ATcHUuAGU6kAkYzRpw5SMLDrs8Jv3yhxsgq8UfL5C4/xiDJXLbfJZgKHYZe7OtcDUBO1ebJBuC9VzFcEkIycPuxlZKfnQi6Y3W3PiYHlajOxndJD8dErG2NU8KyUj89EUf8nIhxKj4GvsvhJilJ+f0xHfvjcWVmfEyn5GSn5+ckGT/JpdMuaaWmeUkpE2h3zvOWekGbsSKwwy802arB4b4zZI7iyU/FyIk1wNkp/XJGPa1DhbsMnIzyZaIFalsZe6tK36S362ST//Cu8zUTKy6LDdHYXJgZKRH2THudMtamJBajR8PskCFj9jPSU/V/7UqVaUdEUy5hLPs2wLkIwkH7yTkWpDZ8nPS5IxNl5noGTkogDJyFKZZKTaoOTnN3mBk5/z+Cc/bZIxXDaDViIZqTZy4gMnPyv4Jz+bpLM38giJX/9NmWSk2gg2+fmRjVu01iidmfa6b1H6x1Fr8DWQh5OMVBuBkp9PYytfOoZL90s+NEjG0I50p5Q+w2MpZijNius1oFMu6gD+4CkJ+t/HgcYaeuB2//De1zoPW/lmr9+lIMiHVs+2eoLHWZbgnUURF4GSkTXTrJA1xARGAUVpezFao6iNUICtfFuOhWdI7/bBsy85yutML2HENRBvurkp0UZc7O2e39A85w0cM1+4M9odtHCE2wfPHf5oQcYhMMgy2QgFVeWY6hmVSSFzrdBGU9RKUxfvRlkjtNEUt/T3NoaK2jQLfTRBM9PfpzH0NlO10EgTVINHpSdf8cU+oZEm6KW7L2OqxFijydhSFcgYKlizS2ilKnaBV6EgualSJa9MgIDPmX6l9/+UM4bqcO0QmqkCn3XPTAG+UCd044o6uQbgzxhysVxoxxXlIFMl0BTEFyuEflxQ4e/GD2QMRQpUqKZF6KgoWpiu7eEaQ6CSgluElopiCwQo1WgK4UB7hJ6KYE8wN3qwxtDyJiop2Ch07RMamY42pYwhUC6HSgq6hL5hwcX0CyoXGepDUqrzuFFoHBY2Qgh1MsN5er2BRRQCwaOM6QY8jaGlTlTncafQOyjsZHq18jaGQMU3qc7jXqG7X+xlOoVcrLQvC3Go+OZaYY5fU9ZCmEVKReVYft2XppVjJYhay70Hel3UWpYgqpPrsDq5J6ikIFWv60+F5hrZ5HGzUgfkYQyBtkOn6nX9oeAc5b5KQeHVRbyMIdAeaEsYI7HGGaXutzAq/qokT2MklLCgIJJqnVWwQX43rxOoYQyBdnZawGjk8lr0jL6csZ3nidQyRoJUYotopIpOtMRoB8isaIkEYzwNovJPVGlIz4UeaIUkLcarVMsQrY3x7OKKWBRH9VP0UCKFVt1XsyirineXpVdjPEFFbWawFkRVIdR8s43e5KplLYRehTittRh6MsYT9NohVYWYwMaiLIVDbgp1T7Gxg955PAKcNqGINGO8QemeDJZNGMPmSLQlMe1+SxutDkFa4eb2kbQrAu2/Rlt90a5StIHRJTbXaGKz9AYl0ibCmH6I/wQYAIByJEXmuf0BAAAAAElFTkSuQmCC" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;margin:15px 5px">
            </button><br>
            <button type="button" id="prev_button" class="btn_click" onClick="" >
              <img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAGYAAABmCAYAAAA53+RiAAAAGXRFWHRTb2Z0d2FyZQBBZG9iZSBJbWFnZVJlYWR5ccllPAAAAyRpVFh0WE1MOmNvbS5hZG9iZS54bXAAAAAAADw/eHBhY2tldCBiZWdpbj0i77u/IiBpZD0iVzVNME1wQ2VoaUh6cmVTek5UY3prYzlkIj8+IDx4OnhtcG1ldGEgeG1sbnM6eD0iYWRvYmU6bnM6bWV0YS8iIHg6eG1wdGs9IkFkb2JlIFhNUCBDb3JlIDcuMS1jMDAwIDc5LmRhYmFjYmIsIDIwMjEvMDQvMTQtMDA6Mzk6NDQgICAgICAgICI+IDxyZGY6UkRGIHhtbG5zOnJkZj0iaHR0cDovL3d3dy53My5vcmcvMTk5OS8wMi8yMi1yZGYtc3ludGF4LW5zIyI+IDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIgeG1sbnM6eG1wTU09Imh0dHA6Ly9ucy5hZG9iZS5jb20veGFwLzEuMC9tbS8iIHhtbG5zOnN0UmVmPSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VSZWYjIiB4bXA6Q3JlYXRvclRvb2w9IkFkb2JlIFBob3Rvc2hvcCAyMy4wIChXaW5kb3dzKSIgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDpGNDkzRUIwNUUxN0UxMUVDOUNDNzg5Q0FCRTA2RjVGNyIgeG1wTU06RG9jdW1lbnRJRD0ieG1wLmRpZDpGNDkzRUIwNkUxN0UxMUVDOUNDNzg5Q0FCRTA2RjVGNyI+IDx4bXBNTTpEZXJpdmVkRnJvbSBzdFJlZjppbnN0YW5jZUlEPSJ4bXAuaWlkOkY0OTNFQjAzRTE3RTExRUM5Q0M3ODlDQUJFMDZGNUY3IiBzdFJlZjpkb2N1bWVudElEPSJ4bXAuZGlkOkY0OTNFQjA0RTE3RTExRUM5Q0M3ODlDQUJFMDZGNUY3Ii8+IDwvcmRmOkRlc2NyaXB0aW9uPiA8L3JkZjpSREY+IDwveDp4bXBtZXRhPiA8P3hwYWNrZXQgZW5kPSJyIj8+dzopnwAACeFJREFUeNrsXQtsVEUUvbvbz+6CVCstLdposYTGT7W1YsVSRQ3UCiKIGBUxGINGUWLEaKLRSKKRKP4CfpoYIoIaAhSkVEQjWotW+cX6A60UUy0UkFDU3e1uP967zDPbsrPdfX3z3rztnOQktHR35t3zZu6d+97MdfT29oINkIUsRBYg85F5yNHIUchM5AikF5mKDCF9yBPIY8h2ZBuyFdmCbEbuRR6R+YIdkgpDxr8MWYosRhYhsw38/sPIJuQe5E7kDiaaEiYKLkBOQlYgy5G5JrZ9ENmArEduQ/441IXJQFYhK5GTkTkS3CCHkFuRW5B1yI6hJMwY5E3I6WyEyAoaQRuRG5D7k1kYEmQ2YzHYB+SL1jDuTyZhaMqaw1gG9kUjchVjh92FmYach5wByYMa5ArkJjsKQ2uN+YzZkHygkLuasdUuwlCU9QByKiQ/apHLWRQntTALkAvZKn2ogLIJryKXySgMpU0WIR9BumDooRu5FPkiGJDuMUqYccjHmJMf6qCgYAlyn9XClCCfQM5UmvyP9chnkbutEmY88inkDUqLU7AZuRj5rZ4POwc5UpQofNzA7FNipjDj2PSlRBlYnCeYvYQLk8UcvfIp8WEms1eWaGEWqegrYcxjdhMmzAK2TlFIHI8w+xkuTCVb0buUjXXBxexXaaQwlJCk3FeBsu+gUMDsmGeUMJQhnqrsagimMnsOWphp8XyRQkKYz+yqW5gMFlFkK1saimxm1wy9wtCj4BnKjkIwg9k3YWHGxPqggiGYw+yckDD0JkuZsp1QlDE7xy3MGN4HFAzH7GijhicMvYxXrGxmCoqZvQcUhiKF6cpepmJ6/wgtmjD0LnGFspWpqGB2jylMpbKTJaiMJQxthZisbGQJJjP7RxWG9qfkKBtZghxm/6jCKN9iva85RRjaXleubGMpypkOfYShPY/Ctte92xqCv4K9trUY9Xx5SwiCPUKbyWU69BGmVFRrb+AF3bU7AFc1+ODPgP3ECaEYc3cF4MGmANyxyw/dYi+htL8wQlb67/8Rgoe+D4T//dPfPTDxSx80/9tjG1H83QCzdvhh9R+h8M/r2rrgvu8CIFCb4khh6NWaIqNb+Ki9C+btCfS5ww74eqACxfmuQ35xTnT1QlWjDzYd6urz+7d/D8HjP3aKapZ0yNKEocMNDH0Y9ss/PXDLjkDUOflQZy9M2u6D7ce6pRXlMPbxmgY/fHE0eh9faA5C9YGQiKZJh0JNGMNfshg73An3nJPK/f/joV6Y8pUf6tq7pBPldxzV5A93d/BvnMvPcMGs0SmiulDgjAiVDYUD+cpF6fB0YTr3b3w4x8381h/2Q7JgL470ChRl3z/8qfa6LBd8MsEDmWkOUd3I14TJE9XC0+PS4LWidOBdAk11czFie/OA9eLsOt4dHimtfr5rvxlHSW2ZF4anOER2JU8TZrTIVhbkp8HKS92Qynn6Q8HB/RjpPPdL0DJRPkdfcu12Pxzp5ItCU/MHpR5IcwrvzmitiVGiW7rj7FRYd5kHPDHe43zy505Y9EMnmL3S+RCjrqqvfeEojIdHC9LgrUvc4HKY0qVRmjCZZrQ2NScF6nAaGBFjGnjptyDc0y/EFomVrSGYhX4u0MP3lc+enw5LLuBPxwKQqe0oOw4x3nEyGhTtVH3tD4ekPMzITYH3cNpIFzhtvLY/CA9/zx+hNDqWFbnh3nNTzZ5ZOzRhaHI3tXWKeipRHApNebgWo5+a8R4hjvaZvZ3wzD6+TyM/srLEA7PPSgELENKEsSSBRdHPlK984RCVh/G4Xthc5oEzDQpN6UIXNnXCsha+KMNwqKwd74Yp2ZaIcnIKtWrEaDga7IXrceRQqMrD+ac54eMJXjjLPThxKBl5N/qv1THWTWekOmAT3ggTMi3dbRKyxMdEy0nd9I0/HLLycK6XxPHA2GH6nA4lI2/d6YfaQ/xMQ066A7bgDVA0wgkWo0PrwQkre0FRWt0VXrgxhz91UPLzKp3JTy0ZGUuUfBT+y4lSiBLustaLY1b3xI09WYuOfm4ef0bVk/wcKBlJuBDFaEBRzhsmhShhPbSetMvQGwq+VpS4YeGYNO7fJJL8jCcZWYbBxedXeiHX7QCJ0K4J0yZLj8g8LxuQ/Iw3GblVbDJSL9o0YVpl61k8yc87OclPivDoYZwEyUjdKwlNmBYZezdQ8rMnSvJTS0YeDUqRjNSLFi0Mapa1h5T8zMC7mkJdP8dVUPLzGAoxcaQLbtvBz3sRKBn5vLl5Lz1o1tYx9Mz/B5B4r2X9X91wY6M/ZgbYESOFoSUjHx+bBpKDztq8UBvMdCJdk8y9rTjTBZ+VeyA73REz3RINlIx8/WK3HUQBpsORyFl2j+w9LslwwRflXjjHG79zID+y+lKPFRlivQjrEHmFO+3Q63HDnVCP4hQOH1gcSkZuvNyyDLFe7OwvDJXqOGiHnud5HFCPK/XS0/mJRkpG0hrFygyxDhxkOvQRhkLmBrtcwUhcFH56pQeuHnmqOJSM3Iaj6opM251H1KAtXfrPB/V2uopoyU/JkpEJB5//R5H9DiulHU2fgs02L1EEveTXYDgRejuueyTLe8ULqltzHbCiQtFOkX0HORcUzMZK5F3aD9HG+xZlI0vQx+7RhKmzm69JAtQzu8cUhgrWbFS2MhUboV+hIF7ossEOmYAkwR5mb4hHGKrDtUbZzBRErXvmHOADjcpuQtHIGwCxhCEVVynbCcUq4FQJdMbxwRplPyGoiXXjDyQMRQpUqOawsqOhOMzs2qFXGAKVFKxWtjQU1TBAqUZnAl9Uq+xpCGrjudHjFYZeb6KSgs3KroNCM7Njq1HCECiXQyUFu5V9daGb2S+uXGSiDy2ozuNSZWNdWAoJ1MnU8zTpRRZRKMSPFcxuIFIYetWJ6jyuV/aOC+uZvY6IFoZAxTepzuNmZfeY2MzslHCx0sE8GKfim4uVODFFWQw6i5SqyrHipi9LK8dqULWW+zp6KWota1DVySWsTh4JKilI1euGUqG5ZrZ4XGbUF4oQhkDHoVP1uqFQcI5yX8vB4LeLRAlDoDPQ5jMmY40zSt1XMxq+VVKkMBqmsaAgmWqd1TAnv0lUA2YIQ6BTN+Yw2rm8Fj2jX8XYIbIhs4TRoJXYItqpohO9YrQGOG+0JIMwkQJR+SeqNCRzoQd6Q5JexttgliBWCxM5xVWxKI7qp8iwy4Deut/Koqw60VOWrMJEgraATGIjiKpC5JrYNu3kamAjZBuwrRBWQiZhIkHnQFNViFLmi4oMDrkp1G1ivoP2PNL2OqkOoZBVmP6gdE8hyybkszUSHUlMp9/SQasjkF44eRgenWHig5NHfdGpUnSAURtba7SwVfpeI9ImSpghiP8EGABFlDJviKYNIAAAAABJRU5ErkJggg==" alt="Red dot" style="width: 46px;border: 4px solid white;border-radius: 50%;padding: 2px 2px;margin:15px 5px">
            </button>
          </div>
          <div class="clr"></div>
        </div>
      </div>
    </div>
    <footer id="footer"><div style="margin-top: 2%;"><img src="data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAMgAAAA2CAYAAACCwNb3AAAABHNCSVQICAgIfAhkiAAAAF96VFh0UmF3IHByb2ZpbGUgdHlwZSBBUFAxAAAImeNKT81LLcpMVigoyk/LzEnlUgADYxMuE0sTS6NEAwMDCwMIMDQwMDYEkkZAtjlUKNEABZiYm6UBoblZspkpiM8FAE+6FWgbLdiMAAAZ7klEQVR4nO2deZwcRdnHv9Xdc+zsZpPsZpPsZkMgJhwxCadAwqHRgBcxhhfyghIBJeIrmldQ8U4giAgCAoKAIGAA4d0AimhQQIgcckm4CZD73vtI9pqju94/nunM1bMzuzu7SWB/n09/ku2pqq7qrqfquQv6hyrgIWAT8BvA51FmOvAUsA74TpZ2TgFeB94Czuhnn3KioqKiZNKkSVdXV1eXDfSzhvDhxm8AnXR5Te6n08qckPZ7EbAm6fc6YPQA9ReAqqqq8gMPPHB1dXX1uIF8zhD2fRj9rD8x7e/KtL+DHvfSJ2UJMCrp71EedQoOrbUe6GcMYd9Hfwkkn/qql22qPtQZwhAGBP0lkKFVeAgfaFiD8Ix8iGhfJbQK4COIsqIUMIFOoAFRXGwCIjnaMON1XSggBuxMKzcMUYLkelcO0JXHc7NhLMI6VwLD4/1pJzGmzUA0RxshhL12+6qAbuTd5EIAKE6rGwV2JZXJ9c5UUt/7A6fQBFKCDLAUsJEXZaaVKUUE8xJk4KPo/042mDCB04HzgCOBEVnKRYENwGPAjcB7WcpNRBQZQeSdFQEvAp9MK3cPcDLQkaN/UWSibAaeA5YB63PUsYAFwNnA4aROvmREEG3k34EbgI1Zyv0E+D6JCVsKXB+/lwunAb9HiBJkDj2JaDpd7A88g7wrG3l3bwAfR8Y/HHgJGENuYs4GH7C9LxXHAIuAFUAbqRqqTqAZaEm67LQyHWllWpFVL7nMKuBq4GN96WAuVFVVlU+ePPmdPmixqpDJoXt57SL75DgYmXjJ5V/xKPdUH56rkff7Pz2MaTLwbB/b/UaWNq/zKP/bHvqQjK961H0mrcyByI6UXOYdEmaGkUBjH8aUftX2dgc5B7gKYS28UBS/ekIofvWEw+PXd4H7gO/RR2ouIMYAjwNT+lC3BHlvIeBSj98HksUcjkzOFuD+tN8mAI8ibGJf2r0ZYf1+1Z8O5oG+vJ+CvNN8WZsSZKLeSXbiGCicCbyMbJ97EleTnTjqkC1+FcKChLOUuwT4bMF7lh+WIN8xGbeQnThqgdeAVxEWLRurcjlwTCE6WEAUShOq8t1B7gL+K+3eG8A/gW0F6gwI1YcQ1uqTiLAGwto8DMwG/lOgZ/UGM4AvedxfjUz6fyD8tgb8yKT7JnA+md4F30BW7ULgMuDd+DOJP78C+DJwWFrZgxGZ6V/xvz8BfMajzVXAUoTvbycxpkOAC4Cvkbqw+oCFiNy0t6AT+AWyIDhJ97uBOcCJaeVXAn9DZBkXJpmKEk8sIpUva0aEuYEWrA9CBNx02SQXe5YTfZBBvHjq9Qjh9oRve9RrINVT4GBkx+mLDHJ0lueWIUqB9PLnJZW5weP31xHWqSdc6lFvB1CeVKbQMsjTaWVyySA94XKP9i/JVjjXDjIB0Ui42Al80e3wpEmTAsCUcDg8yqNub6F8Pl9nR0fH+3V1dfXIBz4F4ZvnxcscDnwL4ecHE14T8Upyy0V3Az8g1XtgFLAfUF+YrnmiGRFsD0y777JYCjjeo971iOKlJ/wG2TGSvR3GInOlqdc9HXx4cTtZF/tcBHI2qavdIuLEMW7cuFlKqeuVUtOKinLJ5fmjtLR0Z3Fx8U3r169fgmh3zgEmAdPiRRYiatN8dOqFwDBkQicjgmzLudCKyCTpO1W5R9lCI+hxz7WNVJIpe7QhrGIuNAJryXQH+kA6fuYikGSB8gVEp04oFDo5FAo9rJTy+gj9glKq1Ofz/ai6urpq69at5yC71q+BO+JFJiEyyr+yNFFoFCNEkow28t8BfoBMplj8bxMRfgcSM0i1G7jYFv93BJnaxjqE/csHF5M5pjd62cd9Ai6BKBKCHojGYjQyGV38g7gQXVlZeY1hGEEvfz+tNbZt4zgOSikMw8AwDJTKX47XWlNcXHz25MmTH1mzZs2DwBOILcGdqIchBBJIqmaT+GCFhJ9MY2c3+RugXihsd1JwIbCVxHfUyMT9LJmyRDvwZvz/PjIXx27yf38DOaa9ChZwBMKyjEYmGciL9pG6bb4PMGHChE+Ypjk1mTiUUkQiEbq7uwmFQowcOZKSkhIcx2HXrl20trYSDocpKirCsvJTnGmtcRznbOBBZGWrJ0EgP0W0QS7v6FLfXYj24sOC3sTO3EPCor6vOYPusf5ayISakUfZKEAgEEjhPZVSdHZ2Ul1dzVlnncXxxx/PuHHjCIVCuwlk8+bNPPXUU9x///00NzdTVFREPt7mpmmOjf/XJkG8IIKul2LgMsTSvSqP8XyY8DqpBsqBNExCqmq1t/Aihv601y9YwPhe1kkZQEdHB8ceeyy33HIL5eWZsmdxcTFjx47l6KOPZv78+SxcuJA1a9YQDOYWX7TWvV05DMTiXUhESSVOELYrXxvSfogvkvuRDcTpb1fWGoVDIyK7XU6qTt8dU/IY3DHl4+Q4AdnNk8e0kYT/lJcCpdjjnhe81PhdedYtOAxEFdkn2LZNeXk5V1xxRQpx2LZNa2srO3fuTNkpDjjgAJYuXYrf78dxBmRReAP4d4HbbCfx4V0MJ3+PgtsR3v81ZCV/k/x27Hzb/gmyO2zz+P2fiJIg3eDVRuakG03+mqjfkzmmZGt6nUeddE1gNuzvcc+rvUGBhfjRPIl8cHfWRhAd+o30oCPu6upizpw5TJqUkOVXr17N4sWL2bBhA4ZhcOihh7J06VIqK4UzmzlzJtOmTeOVV17JaxfJgocRzZa72rjuzq+SW4/fW+xCBOFko2AQ0aStyVE3iKy2kGrEKlQff4e44YBMonRj3H8DfwT+kna/FtnFpibdK0Pcef4vxzOL8B5T8o7o9V4OBaqRd5kNikwrd7b2BgUGstW+hJjaH41f/0QMTT3yqkopTjwxdTxLlixh5cqVtLS00NjYyIMPPsh1110HCEEBTJw4kVisXwqnjYgWy+3vCsTqnq+asrfwsmz/kNxW51PINNa1AlsK0SlS2d2b8bZjXE6mD5aNePCmYxG5rdELSNVughgINyX9/SYyzmSMBH6co+1FwFEe9/eY1qzP7iJaawKBABMmTNh9r7GxkbVr11JaWoplWQSUw+hhIVY8tJzZx8/glNmz+PTHj+eZx/9OiWWgYhHQfWK1Blur8WePe9OA5Yh1P10eGYH4LHm5V6xi4DyTLyVT/TwVWOxR9q8e92YiO8hUMufGKMQXy8tz90lS2aBtZLqog7jd/4FEHE0Ikc+mIMqiKz3qvE3h2ea80eeAKa01pmni9yfMJ+FweLf9A+3Qtd907OIROLEo9Uk7hllZjW+MjdHRgr95O0bnTrQ/iDbSzQ3ZH9/XfvcRjyFsyhfS7p8EzEKs5XXIyjwM4aOzud/cNjBdBOB54Bpkd0vGhQiRJ0+0R5GAquPSys4DPo+MqR5hu0uBA8guo9zqce86ZAdNX8y+ApyFuMO0I2xoOdl3rqsZPK+JDLgEUo5QtDvxuhF+MSfS7SHxu6hYjIY5F9I55eMQ8RifY6MiXfhadjDs9Scoe/pujK5daMufWTYTwxGhMtm3KIqszANhLASxHh9JptuIhThWHpRHG7eRGZNRaFwFnEoqa2fF789Gvi3IxF+EEEp6miXXe/eQPJ53A8KSp+NJhL37qcdvBtlV9cl4CNlx9hgMZLVYg2xlb8WvtciKk3VJV0oRjUZ3yxUAoVAIn8+HduJEE4tCtBuiYXDZKfcCtC9ApHIyTV+4iC0Lb8IuKkU5ec3vs5Bw1reSrvUk3FEGAu8hIa/v9rH+bYgLvBcKyTK2AD/3uH8cEniWjFXIrri5j8+6GvjfHn7/GfDLPrZ9L+K2P9jcQgoMhD8dibhtFCVdgR7q7baev/POO7vvjRgxgpkzZ9LS0iI7y+7PrlB2DKt5R/zajtHdDr6gEE5HK90HzaTppIWoaLZYoxRYCP/q9jWIEPMCBjaw6h3gWIRleZXcu1UDUIPEXnw9S3mN7H466fd0u0vyvRiy+rthyl64G3ggqbzb7kVk7nQvIq47P0KE61xCYR0yeWeQX4z5jxDN1INkCu7paEcUDacg37I7Szn3XeV6Z15wx5f8XrKO2SI/H3pPGIbBypUrOeecc3bfW7x4MeVlZdTcuyxh67B8+Oo2M/7mhahoBJTCCZbQdtQcmmYvBKUg3EH79NmUP3E7Znd7b+QRrzENJNoQ/voG4KOIq041mVlN3kdUsM052tuIaG7c5cTAm+c+j8wAoA09tLsQEdqTy/uz9KcFWel/hahjD0NYyWHxfnUi8sh7yJh6q6Z+Jn6NQQhrMiLP+BGTQnN8LC/QsxrYxSZEzW4gROJmTcmH/bgBUUS4BGUiam9PuHaQZfRhYhUVFfHss8/y7LPPcvzxEl5QXl7ORRddxOMrHsG2k4jacTC72mWHMAzMzjZGP3It4cpJtB/xOYh0ES2rIlx1IMXvv4D298mF/m8Mnpevg6y4b+YqmANhJDIxFzb2st1Wcq/Y6bARtmugXHXq8NYI9hYR8ntnXqinF7E4BhJrPhmhyCPj11TEyNTjtqWUwrZtLr74Yp577rkcj1Jow0xclh9tmAQ3vwXKAK3BsIgNGyX/7xn3IayC29+jkJXvdAZOSB/ChxDurrGRzBUqL8ExEAiwY8cOFixYwOzZs5k7dy5lZWXEYnZuF3elMGIu+x2HaZKHXFZP3Lt4CEMYSPSbX9da4/f70Vrz6KOPsmLFCoKBAD5sLNPq2fNNaxx/gAQtijCfB20OnqFwWW0xRdZslLLQXpSrbdrbduELbuPgqvUcpbLHiTzUcigxfTAGGsd4mfkjvGWIO3UQf+3RWPaRmMFqbDuEHbUxjCYUa+ho/Ddfne6dDO4pbdHYchJaF6Py8ILVyodhr+K0ilR3jpraA9Cx48A4kHCkjEDQxDA70MZGDP0Cb5av4lKVaL+meRowBaV7k6jNxK+fY+6oPZ3SKSsKJtAqpQiFxDVKawcdS+fONMqOouwoaCNOCNC1/2Hg2CKo2xGstnphuXrG4Kn+nMhYsO4DXZSVLEtHgKNtNjS9RU3zMnzqDuaNzOT/HXshBhcAoJxv4GVgW95wCk7jFVj+qTJKLbuqZSVGXVIZoab+Xuzun3LmfqmTq6EhiGHcisrTS1tp0HwPMTDCreuGUxa6DGV+HXyiySyOZxHVWsorAw6pe5TrHr6Q78x9L97O2Sj93byemYyYOhX4U6/rDRJcAjkMiURzZ7XrrNinldqLtdKmRXTk2N1aLLt4BDuP+gIdh5wAkW7RdDVsIrD9fbSVU7E2AUk6kO6s+B8K76yYG1qDoUw0h6Kca4g6X+fOrXM4tzrdyS5B2IaHoPWtm35IIHQFkW5XDtNodgJtoANoRqLwYxp+NOeiimZx3/OzOHPGxn7134i/7yVLDHz6Aayi2TjxqeDoNnDqcGIxDGs0qHK0o/AHPkvVx6Zz1Z8+zsXz1mEYoPPVtO47sBD/mhsH9CmxCNGRlWxalPCs14FidCAE4S5AQyBE6apHMTtacAI5Qwe+GL/S8RxizBsg1wS9A9v4KegIRtxXSSmF1mOIdp2I4TsZ0/RhmAdREriLmi2zmT8+v1iGK2qO5ODPXEI0ns1GO4+g7Wuw1Grax3QwqtmkrnUMweKTUc5iLP9oDGN/jEmXIIktPLpLF0r9EEc3orJxC4YfxxYXlCkXnIRlCnGEu+vobPo2pRUr0WPbqMChdWMJseBhKN9SHPsEzOA4xh+7FPgyduw+lPkuOMJVOzqKUtUYXI6YErbiqJ+hdWz3u3OUhVJejqB7DSyy51ctAFTiUiZOKMn5VWuxsPuDYPkJvf4YZSvvQvv6lQfiOOQEq3yyc/Qe2tiJKruH+cpLtLqK29+dQ9mY+3HsEKY5k9raM5BslLkxbuoicAJoDY5+mNMr5qFU+i6zE1jDb994jzHV/0A7BgancHdDJQsqdmS0qYji2DXMH51Vz58C0zxK2CgFpnET501fnlaiFVhJzZYzUYHXgFH4/LO4s2UE80e+QrrXc039JDCWIgTSzNtly1Lkln0ABgOZy8iyhI31+eUyzMQFGJ07KVr7MqPvX0z1nRdiRLr7YyB0MfgslovzDn4E2xZeXmsYOX5OXvXuaSolNPZTiFymMdTPPYgjgW9OfwLtiF5dqXJ8Oj2LYgJWL7JltNVb8m00YGZXl88fv41wdw3KeB14l+Ko96oWU4kUoBrFR/e5WHgsxNXkd4jjWHLSBhNxYnQHZQJEIpH6QCCQI6ZcoS0fFY9ci/3k78EjetCIdGO11OJrq0PFwmh/EdpM5QK01o1ucVLdrzsQt4SE+kuwjD2dcSMW+xs+62egwIkeyJKnLC6d1bNtxghXof0VGAqi4S1sachtBItEbsbnewnQGFZ263OsF0fNBUvW7s41qPR51NT9lfljvA2hZ+13Qd7t7sOwkERw00mNBY4ibgEvk3Bx/ghAS0vL0xUVFetM0/xIj0SiDIKb30RlDa1VaNMSo2EWmcO27T/G/1tGqufnpYjWxT3HwvXmTQ+NHXz4fdvQehfaGUawaCTHfCJErhyvpj0MhV+WJbOJ703vzOnl9KWq+xCDaU+wiEZOYNmWegwjdfWxYwrT0gwLvMTcURINGG58DJ+5FSNQjWFORKsXqal/DXgHZW5BR7fiOFswAm8zv9wrxPcDB/elRcgM1l+P+Me4BHIycHlbW1uraZoXl5WVLTcMo0d9rLYCfdLHxi30yzds2HBv/NYJpB5U8x/E1aO3rhQDDxWIoLtlJ9ZYhFtzB6VZIVO0VhownN3sVY0uQjWfEVcxJ600bpMOoPzgPMNpFa96tBwiEKzxfmjcFzVqHYE4XsJXD2/glifPp+LIu9CxCpQuQhkzgBmgJde5oUA77TzQ9DKGcT2njnw45/j2YeSyg/wdceUA8cg8D7i9ubn5oWAwOLekpORGYEJvksL1BK01Wms7HA7fuGnTpouRGRBAzglxsZE9k+F98GF1DENzLai0U6x0kjuOBq1+jDvJe4fM9esbn1zBQx2HEus4F8M6HYwDUAxjN1VqMIwStJ6FYc7i0j9dxpJ5XhGLHwjkIpBlSLJoV/10JaKpeHX79u1/nThx4jNKqcO11lUpjol9gNZaBYPBjq6urre2bt26Numnm0lNHn0vg5Myp28IRwJY2kIp0EQx8ngxXRGbYNwWobWJ1gqlNG0NEYqKnkGp4ST7xWltY5pTUEoSSaisG3UHjnEaTmwHluFtXAoMzzwa7tTiHcAvqNFXEusYhREdixkdQ8ypxlCHoPXn8fkOIRaB6Z/8Ebc+/2fOn/GBzEWWi0DeR7x93QCcMiSjyAXAI+vXr28jvyTOfcF44FrkzLrk/lwzQM8rDHydVRCMRzo6rZRW5LaDGHoXmggKP8ooY3lDMdDOuQe0khnmK6ipvwWlzs/Rso1lv86pozNVwF54qH00KhrCcWKcWrYdpWzEAzc17c6t25cwIvYYpnUcjm0xYv9ZfECT9eXjanIVEvAzO/73eCQ++3kkm8gWCn+AzkwkaCaZtQgjQf8tBXrWwCAa/gL+UDxqUr/LLJXbu9gK7kDbDSg1DqX2I7J9CpJppgcYeYVE9wo6cguOMw9NLfdsPgI59yMT51d1cn/tXaCPE7uJv9DJ+vYa5EMgUeR0JfeUVRdx4W1Q0IIE+z85SM/rG+5e93nM4m/LpDEgFsvvJKn5ZW0sr/83qNMB8JV/H63nZ7WF3Lt1FoqT8mq7N2rezqZthMoBPRanex49HXrjRMajfIg6u3PP2Z4GGPk6KzYgsesXIWfd9fuUp17gCSSWe48lD0tAl6CaT2F5QwRDGWhTE+v2EY1MpKh4Nsr4FFpbonSOvEhX1705m3Sx+j83Me2407GjYBSfRk3tw9y/9WcUG2soqYzQhUlTYxl++1RM8zJSs/Fng4VhfpoHmhtQWY781spHzHqNM4avwwz8BZ//W0S6obj8Wu6rHYZZfAdvlzTttoAvqy0mqOai1IViM7FhV9vzeY9zH0NvvHljCLv1IHAukvJmGqnnTCTH+bpI9meHzFy3isz493WIX9UfEQLZO7zgFONAPwgqrv+xwfKJl4B2vV0VOLxH7Ytn85252WKqM7H4c//iD+/cSOm4b2FHwfTPAf1Zuqmlu2knigBBxqCsEpTaidbPIOrvnhACfZdourIV0eCzxZv3S/s9zi8f/z2HHPM1otEAPt8vIfxjpoY38UBjJ9rxg1GJYiyukTwWrmHhR/funb0f6EviuHVIKpdjyDw77iokJ5TEBkikX3oWwYuRHEvTkPP5TiTVkKaB+cjpVv9gbyGOnqA1aGyc6Aa6236B5pjdbuCpSCwUjodu/CuHLKKjcwlad8VntIWiGsUUlPoISpUAjXTsOpPO9ltwm9D9lAGdpFf8w5MW4sR+gNZN8T6UopgGHIMyDkcxNl6nk1js1xjjFvTr2Xs5+hsPkm4mbyRV6xEk0wBZS2qQfAeZRLD3OLSFgnUotSBrwJTSDo69k6izjXDXOs49IPuuYVh3YMeEHbF8mS4xInMs5b5td2LyKZR/KlqNAMfGidRj+V/DDK7kK/s3ccfa8aC+jNYKUyU0SBUV3TQ2fhPMkvwCphwfWiXblTTzyq7it2/cxojSGZgl01BOJVoHMFQUbTaiWE3t1uf49hE9BzpZegfKOAu0H6WaOHUv+q6DhBWknhZ6YdrvQSTHVnKZ9ENfKhAh3P3dIfMI44KiD6fcDuFDiv4e5bzPeWcOYQi9QX8JZKBCX/doNr0hDMFFfwkk3c06PSlZNyKXJCP9iIJOUp0O2zzqFByqUA5kQ/hAo7/RSW8j2QWLkIRgvyIz/f5qEjLFDcjpRMmIIkRzGEIolzBw7isAjBkzxuc4ztRIJPL39vb2PZY5fAh7P/4fpSHNndEmQVIAAAAASUVORK5CYII="></div></footer>
  </div>
</body>
</html>
)rawliteral";


/*IR data structure*/
struct storedIRDataStruct {
  IRData receivedIRData;
  // extensions for sendRaw
  uint8_t rawCode[RAW_BUFFER_LENGTH]; // The durations if raw
  uint8_t rawCodeLength; // The length of the code
} sStoredIRData;

void storeCode(IRData *aIRReceivedData);
void sendCode(storedIRDataStruct *aIRDataToSend);
int mode_sw, learn_sw;
int SRmode = 0;
int t0size, t1size, t2size, t3size, t4size, t5size, t6size, t7size, t8size, t9size;
uint8_t array0[750], array1[750], array2[750], array3[750], array4[750], array5[750], array6[750], array7[750], array8[750], array9[750];
const long touchDelay = 350; //ms
int value = 0;
int threshold = 40;
int thresholdT1 = 40;
bool touch_pwr = false;
bool touch_ok = false;
bool touch_up = false;
bool touch_down = false;
bool touch_left = false;
bool touch_right = false;
bool touch_next = false;
bool touch_prev = false;
bool touch_plus = false;
bool touch_minus = false;
bool boot = true;
unsigned long lasttouch = 0;
unsigned long lastwificheck = 0;
unsigned long lastmqttcheck = 0;
volatile unsigned long sinceLastTouchT0 = 0;
volatile unsigned long sinceLastTouchT1 = 0;
volatile unsigned long sinceLastTouchT2 = 0;
volatile unsigned long sinceLastTouchT3 = 0;
volatile unsigned long sinceLastTouchT4 = 0;
volatile unsigned long sinceLastTouchT5 = 0;
volatile unsigned long sinceLastTouchT6 = 0;
volatile unsigned long sinceLastTouchT7 = 0;
volatile unsigned long sinceLastTouchT8 = 0;
volatile unsigned long sinceLastTouchT9 = 0;

/*Touch interrupt routines*/
void IRAM_ATTR gotTouch_minus() {
  touch_minus = true;
}
void IRAM_ATTR gotTouch_plus() {
  touch_plus = true;
}
void IRAM_ATTR gotTouch_next() {
  touch_next = true;
}
void IRAM_ATTR gotTouch_prev() {
  touch_prev = true;
}
void IRAM_ATTR gotTouch_pwr() {
  touch_pwr = true;
}
void IRAM_ATTR gotTouch_left() {
  touch_left = true;
}
void IRAM_ATTR gotTouch_ok() {
  touch_ok = true;
}
void IRAM_ATTR gotTouch_right() {
  touch_right = true;
}
void IRAM_ATTR gotTouch_down() {
  touch_down = true;
}
void IRAM_ATTR gotTouch_up() {
  touch_up = true;
}

/* Function for touch debouncing*/
bool touchDelayComp(unsigned long lastTouch)
{
  if (millis() - lastTouch < touchDelay) return false;
  return true;
}

/*Fucntion to reboot ESP32 incase of mode change*/
void modereset()
{
  if (digitalRead(mode_switch) != mode_sw || digitalRead(learn_switch) != learn_sw)
  {
    ESP.restart();
  }
}


void MQTT_connect() {
  int8_t ret;

  // Stop if already connected.
  if (mqtt.connected()) {
    return;
  }

if(millis() - lastmqttcheck > 10000 || boot == true)
{
  if(boot == true)
  {
    boot = false;
    Serial.println("Boot flag detected ");
  }
  Serial.print("Connecting to MQTT... ");
  int8_t retry = 5;
  while ((ret = mqtt.connect()) != 0) { // connect will return 0 for connected
    Serial.println(mqtt.connectErrorString(ret));
    Serial.println("Retrying MQTT connection ");
    mqtt.disconnect();
    retry--;
    Serial.print(".");
    if (retry == 0)
    {
     lastmqttcheck = millis();
     Serial.println("Retry failed . will try after 10Sec ");
     return; 
    }
    
  }
  Serial.println("MQTT Connected!");
}
  
}

/*Function to interpret and identify touch*/
void touch_detect()
{
  if (touch_pwr) {
    touch_pwr = false;
    if (touchDelayComp(sinceLastTouchT4))
    {
      value = value - 1;
      Serial.println("PWR button");
      IrSender.sendRaw(array4, t4size, 38);
      sinceLastTouchT4 = millis();
      lasttouch = millis();
    }
  }
  if (touch_ok) {
    touch_ok = false;
    if (touchDelayComp(sinceLastTouchT6))
    {
      value = value - 1;
      Serial.println("Ok button");
      IrSender.sendRaw(array6, t6size, 38);
      sinceLastTouchT6 = millis();
      lasttouch = millis();
    }
  }
  if (touch_up) {
    touch_up = false;
    if (touchDelayComp(sinceLastTouchT9))
    {
      value = value - 1;
      Serial.println("Up button");
      IrSender.sendRaw(array9, t9size, 38);
      sinceLastTouchT9 = millis();
      lasttouch = millis();
    }
  }
  if (touch_down) {
    touch_down = false;
    if (touchDelayComp(sinceLastTouchT8))
    {
      value = value - 1;
      Serial.println("Down button");
      IrSender.sendRaw(array8, t8size, 38);
      sinceLastTouchT8 = millis();
      lasttouch = millis();
    }
  }
  if (touch_left) {
    touch_left = false;
    if (touchDelayComp(sinceLastTouchT7))
    {
      value = value - 1;
      Serial.println("Left button");
      IrSender.sendRaw(array7, t7size, 38);
      sinceLastTouchT7 = millis();
      lasttouch = millis();
    }
  }
  if (touch_right) {
    touch_right = false;
    if (touchDelayComp(sinceLastTouchT5))
    {
      value = value - 1;
      Serial.println("Right button");
      IrSender.sendRaw(array5, t5size, 38);
      sinceLastTouchT5 = millis();
      lasttouch = millis();
    }
  }
  if (touch_next) {
    touch_next = false;
    if (touchDelayComp(sinceLastTouchT2))
    {
      value = value - 1;
      Serial.println("Next button");
      IrSender.sendRaw(array2, t2size, 38);
      sinceLastTouchT2 = millis();
      lasttouch = millis();
    }
  }
  if (touch_prev) {
    touch_prev = false;
    if (touchDelayComp(sinceLastTouchT3))
    {
      value = value - 1;
      Serial.println("Prev button");
      IrSender.sendRaw(array3, t3size, 38);
      sinceLastTouchT3 = millis();
      lasttouch = millis();
    }
  }

  if (touch_plus) {
    touch_plus = false;
    if (touchDelayComp(sinceLastTouchT1))
    {
      value = value - 1;
      Serial.println("Plus button");
      IrSender.sendRaw(array1, t1size, 38);
      sinceLastTouchT1 = millis();
      lasttouch = millis();
    }
  }

  if (touch_minus) {
    touch_minus = false;
    if (touchDelayComp(sinceLastTouchT0))
    {
      value = value - 1;
      Serial.println("Minus button");
      IrSender.sendRaw(array0, t0size, 38);
      sinceLastTouchT0 = millis();
      lasttouch = millis();
    }
  }
}

/*RGB LED flashing when a signal data is saved*/
void rgbeffect()
{
  for (int i = 0; i < 3; i++)
    {
      digitalWrite(19, LOW);
      digitalWrite(5, HIGH);
      delay(100);
      digitalWrite(5, LOW);
      digitalWrite(18, HIGH);
      delay(100);
      digitalWrite(18, LOW);
      digitalWrite(19, HIGH);
      delay(100);
    }
    digitalWrite(19, HIGH);
}

/*Function to save the IR sginal data in the learing mode*/
void storeCode(IRData *aIRReceivedData) {
  if (aIRReceivedData->flags & IRDATA_FLAGS_IS_REPEAT) {
    Serial.println(F("Ignore repeat"));
    return;
  }
  if (aIRReceivedData->flags & IRDATA_FLAGS_IS_AUTO_REPEAT) {
    Serial.println(F("Ignore autorepeat"));
    return;
  }
  if (aIRReceivedData->flags & IRDATA_FLAGS_PARITY_FAILED) {
    Serial.println(F("Ignore parity error"));
    return;
  }
  /*
     Copy decoded data
  */
  sStoredIRData.receivedIRData = *aIRReceivedData;
  sStoredIRData.rawCodeLength = IrReceiver.decodedIRData.rawDataPtr->rawlen - 1;
  IrReceiver.compensateAndStoreIRResultInArray(sStoredIRData.rawCode);
  if (sStoredIRData.receivedIRData.protocol == UNKNOWN) {
    Serial.print(F("Received unknown code and store "));
    Serial.print(IrReceiver.decodedIRData.rawDataPtr->rawlen - 1);
    Serial.println(F(" timing entries as raw "));
    IrReceiver.printIRResultRawFormatted(&Serial, true); // Output the results in RAW format
    sStoredIRData.rawCodeLength = IrReceiver.decodedIRData.rawDataPtr->rawlen - 1;
    /*
       Store the current raw data in a dedicated array for later usage
    */
    IrReceiver.compensateAndStoreIRResultInArray(sStoredIRData.rawCode);

  } else {
    IrReceiver.printIRResultShort(&Serial);
    sStoredIRData.receivedIRData.flags = 0; // clear flags -esp. repeat- for later sending
    Serial.println();
  }
  Serial.println(" timing entries as raw ");
  IrReceiver.printIRResultRawFormatted(&Serial, true); // Output the results in RAW format
  Serial.println("");
  for (uint8_t i = 0; i < sStoredIRData.rawCodeLength; i++)
  {
    Serial.print(sStoredIRData.rawCode[i]);
    Serial.print(" , ");
  }
  Serial.println();
  uint8_t size1 = sizeof(sStoredIRData.rawCode);
  //uint8_t array2[sStoredIRData.rawCodeLength];
  //memcpy( array2, sStoredIRData.rawCode, sStoredIRData.rawCodeLength );
  if (touchRead(T0) < threshold)
  {
    Serial.println("Saving - key");
    File file_t0 = SPIFFS.open("/0.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t0.println(sStoredIRData.rawCode[n]);
    }
    file_t0.close();
    rgbeffect();
  }
  else if (touchRead(T1) < thresholdT1)
  {
    Serial.println("Saving + key");
    File file_t1 = SPIFFS.open("/1.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t1.println(sStoredIRData.rawCode[n]);
    }
    file_t1.close();
    rgbeffect();
  }
  else if (touchRead(T2) < threshold)
  {
    Serial.println("Saving next key");
    File file_t2 = SPIFFS.open("/2.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t2.println(sStoredIRData.rawCode[n]);
    }
    file_t2.close();
    rgbeffect();
  }
  else if (touchRead(T3) < threshold)
  {
    Serial.println("Saving prev key");
    File file_t3 = SPIFFS.open("/3.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t3.println(sStoredIRData.rawCode[n]);
    }
    file_t3.close();
    rgbeffect();
  }
  else if (touchRead(T4) < threshold)
  {
    Serial.println("Saving pwr key");
    File file_t4 = SPIFFS.open("/4.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t4.println(sStoredIRData.rawCode[n]);
    }
    file_t4.close();
    rgbeffect();
  }
  else if (touchRead(T5) < threshold)
  {
    Serial.println("Saving > key");
    File file_t5 = SPIFFS.open("/5.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t5.println(sStoredIRData.rawCode[n]);
    }
    file_t5.close();
    rgbeffect();
  }
  else if (touchRead(T6) < threshold)
  {
    Serial.println("Saving ok key");
    File file_t6 = SPIFFS.open("/6.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t6.println(sStoredIRData.rawCode[n]);
    }
    file_t6.close();
    rgbeffect();
  }
  else if (touchRead(T7) < threshold)
  {
    Serial.println("Saving < key");
    File file_t7 = SPIFFS.open("/7.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t7.println(sStoredIRData.rawCode[n]);
    }
    file_t7.close();
    rgbeffect();
  }
  else if (touchRead(T8) < thresholdT1)
  {
    Serial.println("Saving Down key");
    File file_t8 = SPIFFS.open("/8.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t8.println(sStoredIRData.rawCode[n]);
    }
    file_t8.close();
    rgbeffect();
  }
  else if (touchRead(T9) < threshold)
  {
    Serial.println("Saving Up key");
    File file_t9 = SPIFFS.open("/9.txt", FILE_WRITE);
    for (int n = 0; n < sStoredIRData.rawCodeLength; n++)
    {
      file_t9.println(sStoredIRData.rawCode[n]);
    }
    file_t9.close();
    rgbeffect();
  }
  else
  {
    Serial.println("No key pressed");
    return;
  }
  Serial.println("Key Code Saved");
}


/*Function to handle WebSocket Messages*/
void handleWebSocketMessage(void *arg, uint8_t *data, size_t len) {
  AwsFrameInfo *info = (AwsFrameInfo*)arg;
  if (info->final && info->index == 0 && info->len == len && info->opcode == WS_TEXT) {
    data[len] = 0;
    if (strcmp((char*)data, "pwrbtn") == 0) {
      Serial.println("PWR button");
      IrSender.sendRaw(array4, t4size, 38);
    }
    else if (strcmp((char*)data, "upbtn") == 0) {
      Serial.println("Up button");
      IrSender.sendRaw(array9, t9size, 38);
    }
    else if (strcmp((char*)data, "downbtn") == 0) {
      Serial.println("Down button");
      IrSender.sendRaw(array8, t8size, 38);
    }
    else if (strcmp((char*)data, "leftbtn") == 0) {
      Serial.println("Left button");
      IrSender.sendRaw(array7, t7size, 38);
    }
    else if (strcmp((char*)data, "okbtn") == 0) {
      Serial.println("Ok button");
      IrSender.sendRaw(array6, t6size, 38);
    }
    else if (strcmp((char*)data, "rightbtn") == 0) {
      Serial.println("Right button");
      IrSender.sendRaw(array5, t5size, 38);
    }
    else if (strcmp((char*)data, "plusbtn") == 0) {
      Serial.println("Plus button");
      IrSender.sendRaw(array1, t1size, 38);
    }
    else if (strcmp((char*)data, "minusbtn") == 0) {
      Serial.println("Minus button");
      IrSender.sendRaw(array0, t0size, 38);
    }
    else if (strcmp((char*)data, "nextbtn") == 0) {
      Serial.println("Next button");
      IrSender.sendRaw(array2, t2size, 38);
    }
    else if (strcmp((char*)data, "prevbtn") == 0) {
      Serial.println("Prev button");
      IrSender.sendRaw(array3, t3size, 38);
    }
  }
}

/*Event handler Function*/
void onEvent(AsyncWebSocket *server, AsyncWebSocketClient *client, AwsEventType type,
             void *arg, uint8_t *data, size_t len) {
  switch (type) {
    case WS_EVT_CONNECT:
      Serial.printf("WebSocket client #%u connected from %s\n", client->id(), client->remoteIP().toString().c_str());
      break;
    case WS_EVT_DISCONNECT:
      Serial.printf("WebSocket client #%u disconnected\n", client->id());
      break;
    case WS_EVT_DATA:
      handleWebSocketMessage(arg, data, len);
      break;
    case WS_EVT_PONG:
    case WS_EVT_ERROR:
      break;
  }
}

/*Function to initialise swebsocket*/
void initWebSocket() {
  ws.onEvent(onEvent);
  server.addHandler(&ws);
}


void MQTT_loop()
{
  if (WiFi.status() != WL_CONNECTED && millis()-lastwificheck > 10000)
  {
    Serial.print("Connecting to Wifi");
  uint8_t errcount = 25;
    WiFi.reconnect();
  
  while (WiFi.status() != WL_CONNECTED) {
    delay(50);
    Serial.print(".");
    errcount--;
    if (errcount == 0)
    {
      Serial.println("Wifi connection failed");
      lastwificheck = millis();
      break;
    }
    if (WiFi.status() == WL_CONNECTED)
    {
    Serial.println("WiFi connected");
    Serial.println("IP address: "); 
    Serial.println(WiFi.localIP());
    }
  }
    
  }
  else if (WiFi.status() == WL_CONNECTED)
  {
        MQTT_connect();
      
  Adafruit_MQTT_Subscribe *subscription;
  while ((subscription = mqtt.readSubscription(50))) {
    if (subscription == &SRemote) {
      Serial.print(F("Got: "));
      Serial.println((char *)SRemote.lastread);
      
      if (String((char *)SRemote.lastread) == String("power")||String((char *)SRemote.lastread) == String("Power")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending power button code ");
      IrSender.sendRaw(array4, t4size, 38);
      }
      else if (String((char *)SRemote.lastread) == String("ok") ||String((char *)SRemote.lastread) == String("Ok")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Ok button code ");
      IrSender.sendRaw(array6, t6size, 38);
      } 
      else if (String((char *)SRemote.lastread) == String("left") ||String((char *)SRemote.lastread) == String("Left")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Left button code ");
      IrSender.sendRaw(array7, t7size, 38);
      } 
      else if (String((char *)SRemote.lastread) == String("right")||String((char *)SRemote.lastread) == String("Right")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Right button code ");
      IrSender.sendRaw(array5, t5size, 38);
      } 
      else if (String((char *)SRemote.lastread) == String("up")||String((char *)SRemote.lastread) == String("Up")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Up button code ");
      IrSender.sendRaw(array9, t9size, 38);
      } 
      else if (String((char *)SRemote.lastread) == String("down")||String((char *)SRemote.lastread) == String("Down")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Down button code ");
      IrSender.sendRaw(array8, t8size, 38);
      } 
      else if (String((char *)SRemote.lastread) == String("plus")||String((char *)SRemote.lastread) == String("Plus")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Plus button code ");
      IrSender.sendRaw(array1, t1size, 38);
      } 
      else if (String((char *)SRemote.lastread) == String("minus")||String((char *)SRemote.lastread) == String("Minus")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Minus button code ");
      IrSender.sendRaw(array0, t0size, 38);
      } 
      else if (String((char *)SRemote.lastread) == String("next")||String((char *)SRemote.lastread) == String("Next")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Next button code ");
      IrSender.sendRaw(array2, t2size, 38);
      } 
      else if (String((char *)SRemote.lastread) == String("previous")||String((char *)SRemote.lastread) == String("Previous")) // hear we are checking for the string Big FM
      {
        Serial.println("Sending Previous button code ");
      IrSender.sendRaw(array3, t3size, 38);
      }  
       
    }
    
  }
  }
}

/*Setup Function*/
void setup() {
  pinMode(mode_switch, INPUT);
  pinMode(learn_switch, INPUT);
  pinMode(5, OUTPUT);
  pinMode(18, OUTPUT);
  pinMode(19, OUTPUT);
  digitalWrite(5, LOW);
  digitalWrite(18, LOW);
  digitalWrite(19, LOW);
  mode_sw = digitalRead(mode_switch);
  learn_sw = digitalRead(learn_switch);
  Serial.begin(115200);
  
  delay(1000); // give me time to bring up serial monitor
  if (!SPIFFS.begin(true)) {
    Serial.println("An Error has occurred while mounting SPIFFS");
    return;
  }
  Serial.println("ESP32 Touch Interrupt Test");
  if (learn_sw)
  {
    SRmode = 0;
    for (int i = 0; i < 3; i++)
    {
      digitalWrite(19, LOW);
      digitalWrite(5, HIGH);
      delay(100);
      digitalWrite(5, LOW);
      digitalWrite(18, HIGH);
      delay(100);
      digitalWrite(18, LOW);
      digitalWrite(19, HIGH);
      delay(100);
    }
    digitalWrite(19, HIGH);
    // Start the receiver and if not 3. parameter specified, take LED_BUILTIN pin from the internal boards definition as default feedback LED
    IrReceiver.begin(IR_RECEIVE_PIN, ENABLE_LED_FEEDBACK);

    Serial.print(F("Ready to receive IR signals of protocols: "));
    printActiveIRProtocols(&Serial);
    Serial.println(F("at pin " STR(IR_RECEIVE_PIN)));
  }
  else
  {

    File file0 = SPIFFS.open("/0.txt", FILE_READ);
    File file1 = SPIFFS.open("/1.txt", FILE_READ);
    File file2 = SPIFFS.open("/2.txt", FILE_READ);
    File file3 = SPIFFS.open("/3.txt", FILE_READ);
    File file4 = SPIFFS.open("/4.txt", FILE_READ);
    File file5 = SPIFFS.open("/5.txt", FILE_READ);
    File file6 = SPIFFS.open("/6.txt", FILE_READ);
    File file7 = SPIFFS.open("/7.txt", FILE_READ);
    File file8 = SPIFFS.open("/8.txt", FILE_READ);
    File file9 = SPIFFS.open("/9.txt", FILE_READ);
    String string_temp;
    int counter = 0;
    while (file0.available()) {
      string_temp = file0.readStringUntil('\r');
      array0[counter] = string_temp.toInt();
      counter++;
    }
    t0size = counter;
    file0.close();
    string_temp = "";
    counter = 0;
    while (file1.available()) {
      string_temp = file1.readStringUntil('\r');
      array1[counter] = string_temp.toInt();
      counter++;
    }
    t1size = counter;
    file1.close();
    string_temp = "";
    counter = 0;
    while (file2.available()) {
      string_temp = file2.readStringUntil('\r');
      array2[counter] = string_temp.toInt();
      counter++;
    }
    t2size = counter;
    file2.close();
    string_temp = "";
    counter = 0;
    while (file3.available()) {
      string_temp = file3.readStringUntil('\r');
      array3[counter] = string_temp.toInt();
      counter++;
    }
    t3size = counter;
    file3.close();
    string_temp = "";
    counter = 0;
    while (file4.available()) {
      string_temp = file4.readStringUntil('\r');
      array4[counter] = string_temp.toInt();
      counter++;
    }
    t4size = counter;
    file4.close();
    string_temp = "";
    counter = 0;
    while (file5.available()) {
      string_temp = file5.readStringUntil('\r');
      array5[counter] = string_temp.toInt();
      counter++;
    }
    t5size = counter;
    file5.close();
    string_temp = "";
    counter = 0;
    while (file6.available()) {
      string_temp = file6.readStringUntil('\r');
      array6[counter] = string_temp.toInt();
      counter++;
    }
    t6size = counter;
    file6.close();
    string_temp = "";
    counter = 0;
    while (file7.available()) {
      string_temp = file7.readStringUntil('\r');
      array7[counter] = string_temp.toInt();
      counter++;
    }
    t7size = counter;
    file7.close();
    string_temp = "";
    counter = 0;
    while (file8.available()) {
      string_temp = file8.readStringUntil('\r');
      array8[counter] = string_temp.toInt();
      counter++;
    }
    t8size = counter;
    file8.close();
    string_temp = "";
    counter = 0;
    while (file9.available()) {
      string_temp = file9.readStringUntil('\r');
      array9[counter] = string_temp.toInt();
      counter++;
    }
    t9size = counter;
    file9.close();
    string_temp = "";
    counter = 0;
    Serial.println("Key read from files");
    touchAttachInterrupt(T0, gotTouch_minus, threshold);
    touchAttachInterrupt(T1, gotTouch_plus, thresholdT1);
    touchAttachInterrupt(T2, gotTouch_next, threshold);
    touchAttachInterrupt(T3, gotTouch_prev, threshold);
    touchAttachInterrupt(T4, gotTouch_pwr, threshold);
    touchAttachInterrupt(T5, gotTouch_right, threshold);
    touchAttachInterrupt(T6, gotTouch_ok, threshold);
    touchAttachInterrupt(T7, gotTouch_left, threshold);
    touchAttachInterrupt(T8, gotTouch_down, threshold);
    touchAttachInterrupt(T9, gotTouch_up, threshold);
    IrSender.begin(IR_SEND_PIN, ENABLE_LED_FEEDBACK); // Specify send pin and enable feedback LED at default feedback LED pin
    if (mode_sw)
    {
      //wifi mode
      Serial.println("Wifi Mode");// Start access point
      
      WiFi.mode(WIFI_STA);
      WiFiManager wm;
      if(touchRead(T0) < 30 && touchRead(T3) < 30 && touchRead(T4) < 30 )
  {
    while(touchRead(T6) > 30)
    {
      digitalWrite(18, LOW);
      digitalWrite(5, HIGH);
      delay(100);
      digitalWrite(5, LOW);
      digitalWrite(18, HIGH);
      delay(100);
    }
    wm.resetSettings();
  }
      bool res;
      res = wm.autoConnect("SmartRemote","circuitdigest"); // password protected ap

    if(!res) {
        Serial.println("Failed to connect");
        lastwificheck = millis();
        // ESP.restart();
    } 
    else {
        //if you get here you have connected to the WiFi    
        Serial.println("WiFi connected...");
        lastwificheck = millis();
    }

  Serial.println();
  if (WiFi.status() == WL_CONNECTED)
  {
  Serial.println("WiFi connected");
  Serial.println("IP address: "); 
  Serial.println(WiFi.localIP());
  }
  if (!MDNS.begin("smartremote")) {
    Serial.println("Error setting up MDNS responder!");
  }

  MDNS.addService("http", "tcp", 80);

  Serial.println("Connect using http://smartremote.local");

  // Setup MQTT subscription for onoff feed.
  mqtt.subscribe(&SRemote);




      
      initWebSocket();

  // Route for root / web page
  server.on("/", HTTP_GET, [](AsyncWebServerRequest *request){
    request->send_P(200, "text/html", index_html);
  });
  AsyncElegantOTA.begin(&server, "admin", "circuitdigest");
  // Start server
  server.begin();
      SRmode = 1;
      for (int i = 0; i < 3; i++)
      {

        digitalWrite(5, HIGH);
        delay(100);
        digitalWrite(5, LOW);
        delay(100);
      }
      digitalWrite(5, HIGH);
    }
    else
    {
      SRmode = 2;
      Serial.println("Normal Mode");
      for (int i = 0; i < 3; i++)
      {
        digitalWrite(18, HIGH);
        delay(100);
        digitalWrite(18, LOW);
        delay(100);
      }
      digitalWrite(18, HIGH);
    }
  }
  lasttouch = millis();
}

/*Loop Function*/
void loop() {
  modereset();
  if (SRmode == 0)
  {
    if (IrReceiver.available()) {
      storeCode(IrReceiver.read());
      IrReceiver.resume(); // resume receiver
    }
  }
  else
  {
    touch_detect();
    if (SRmode == 1)
    {
      MQTT_loop();
      /*Web client handling*/
      ws.cleanupClients();
    }
    else
    {
      /*In normal mode the remote will goto sleep after 20 Seconds. Adjust the sleep time by modifiying the value below*/
      if(millis()- lasttouch > 20000)
      {
      esp_sleep_enable_touchpad_wakeup();
      Serial.println("Going to sleep now");
      esp_deep_sleep_start();
      }
    }
  }

}
